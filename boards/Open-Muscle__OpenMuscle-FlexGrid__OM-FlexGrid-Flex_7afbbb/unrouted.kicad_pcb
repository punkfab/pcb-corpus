# Repository punkfab/pcb-corpus

## KiCad design boards/Open-Muscle__OpenMuscle-FlexGrid__OM-FlexGrid-Flex_7afbbb/unrouted.kicad_pcb

Board: 2 copper layers, 260.0 x 78.7 mm, 61 parts (0 on the bottom side), 19 nets, no tracks yet.

Parts:
J1: Conn_01x19_Pin; PinHeader_1x19_P1.27mm_Vertical
JP1, JP2, JP3, JP4, JP5, JP6, JP7, JP8, JP9, JP10, JP11, JP12, JP13, JP14, JP15, JP16, JP17, JP18, JP19, JP20, JP21, JP22, JP23, JP24, JP25, JP26, JP27, JP28, JP29, JP30, JP31, JP32, JP33, JP34, JP35, JP36, JP37, JP38, JP39, JP40, JP41, JP42, JP43, JP44, JP45, JP46, JP47, JP48, JP49, JP50, JP51, JP52, JP53, JP54, JP55, JP56, JP57, JP58, JP59, JP60: Jumper_2_Open; 10mmPad

Connections:
COL_0: J1.1, JP1.1 (A), JP16.1 (A), JP31.1 (A), JP46.1 (A)
COL_1: J1.2, JP2.1 (A), JP17.1 (A), JP32.1 (A), JP47.1 (A)
COL_2: J1.3, JP3.1 (A), JP18.1 (A), JP33.1 (A), JP48.1 (A)
COL_3: J1.4, JP4.1 (A), JP19.1 (A), JP34.1 (A), JP49.1 (A)
COL_4: J1.5, JP5.1 (A), JP20.1 (A), JP35.1 (A), JP50.1 (A)
COL_5: J1.6, JP6.1 (A), JP21.1 (A), JP36.1 (A), JP51.1 (A)
COL_6: J1.7, JP7.1 (A), JP22.1 (A), JP37.1 (A), JP52.1 (A)
COL_7: J1.8, JP8.1 (A), JP23.1 (A), JP38.1 (A), JP53.1 (A)
COL_8: J1.9, JP9.1 (A), JP24.1 (A), JP39.1 (A), JP54.1 (A)
COL_9: J1.10, JP10.1 (A), JP25.1 (A), JP40.1 (A), JP55.1 (A)
COL_10: J1.11, JP11.1 (A), JP26.1 (A), JP41.1 (A), JP56.1 (A)
COL_11: J1.12, JP12.1 (A), JP27.1 (A), JP42.1 (A), JP57.1 (A)
COL_12: J1.13, JP13.1 (A), JP28.1 (A), JP43.1 (A), JP58.1 (A)
COL_13: J1.14, JP14.1 (A), JP29.1 (A), JP44.1 (A), JP59.1 (A)
COL_14: J1.15, JP15.1 (A), JP30.1 (A), JP45.1 (A), JP60.1 (A)
ROW_0: J1.16, JP1.2 (B), JP2.2 (B), JP3.2 (B), JP4.2 (B), JP5.2 (B), JP6.2 (B), JP7.2 (B), JP8.2 (B), JP9.2 (B), JP10.2 (B), JP11.2 (B), JP12.2 (B), JP13.2 (B), JP14.2 (B), JP15.2 (B)
ROW_1: J1.17, JP16.2 (B), JP17.2 (B), JP18.2 (B), JP19.2 (B), JP20.2 (B), JP21.2 (B), JP22.2 (B), JP23.2 (B), JP24.2 (B), JP25.2 (B), JP26.2 (B), JP27.2 (B), JP28.2 (B), JP29.2 (B), JP30.2 (B)
ROW_2: J1.18, JP31.2 (B), JP32.2 (B), JP33.2 (B), JP34.2 (B), JP35.2 (B), JP36.2 (B), JP37.2 (B), JP38.2 (B), JP39.2 (B), JP40.2 (B), JP41.2 (B), JP42.2 (B), JP43.2 (B), JP44.2 (B), JP45.2 (B)
ROW_3: J1.19, JP46.2 (B), JP47.2 (B), JP48.2 (B), JP49.2 (B), JP50.2 (B), JP51.2 (B), JP52.2 (B), JP53.2 (B), JP54.2 (B), JP55.2 (B), JP56.2 (B), JP57.2 (B), JP58.2 (B), JP59.2 (B), JP60.2 (B)

## KiCad design boards/OpenLightingProject__rp2040-dmxsun__baseboard_2slots/unrouted.kicad_pcb

Board: 2 copper layers, 216.8 x 60.0 mm, 45 parts (4 on the bottom side), 26 nets, no tracks yet.

Parts:
C1, C2, C3, C4, C5, C8, C21, C27: 100nF; C_0603_1608Metric
C9, C10, C13, C23, C29: 1nF; C_0603_1608Metric
C14, C15, C16, C19, C25: 82µF; CP_Radial_D6.3mm_P2.50mm
D1: SS14; D_SMA
H1, H2, H3, H5, H6, H8: MountingHole; MountingHole_3.2mm_M3
J1: IO-Board_00; PinSocket_2x06_P2.54mm_Vertical
J2: IO-Board_01; PinSocket_2x06_P2.54mm_Vertical
J3: Conn_02x04_Odd_Even; PinHeader_2x04_P2.54mm_Vertical
J5: USB_B_Micro; USB_Micro-B_Wuerth_629105150521
J6: Conn_01x05: Adafruit 1833; PinHeader_1x05_P2.54mm_Vertical
J7: Screw_Terminal_01x04; TerminalBlock_Altech_AK300-4_P5.00mm
J8, J9: Conn_02x02_Odd_Even; PinHeader_2x02_P2.54mm_Vertical
J10, J11, J12: Conn_01x04_Male; NS-Tech_Grove_1x04_P2mm_Vertical
J13, J14: Conn_01x04_Male; JST_SH_BM04B-SRSS-TB_1x04-1MP_P1.00mm_Vertical
J15: Conn_02x02_Odd_Even; PinSocket_2x02_P2.54mm_Vertical
R1, R2: 2k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SYM1: Logo_Open_Hardware_Large; OSHW-Logo2_14.6x12mm_SilkScreen
U1: NRF24L01_Breakout; nRF24L01_Breakout
U2: Pico; RPi_Pico_SMD_TH
U3: W5500_Mini_TH; W5500_Mini

Connections:
+3.3V: C1.1, C8.1, C13.1, C14.1, C19.1, C21.1, C23.1, C25.1, C27.1, C29.1, J1.6, J2.6, J2.8, J10.3, J11.3, J13.3, J14.3, R1.1, R2.1, U1.2 (VCC), U2.36 (3V3), U3.10 (VDD), U3.11 (VDD)
/INT_RF24: J3.3, U1.8 (IRQ)
/INT_WIZ: J3.5, U3.6 (~INT)
/IO0_GP0: J1.11, U2.9 (GPIO6)
/IO0_GP1: J1.9, U2.10 (GPIO7)
/IO0_GP2: J1.7, U2.11 (GPIO8)
/IO0_GP3: J1.5, U2.12 (GPIO9)
/IO1_GP0: J2.11, U2.14 (GPIO10)
/IO1_GP1: J2.9, U2.15 (GPIO11)
/IO1_GP2: J2.7, U2.16 (GPIO12)
/IO1_GP3: J2.5, U2.17 (GPIO13)
/NRF_CE: U1.3 (CE), U2.34 (GPIO28_ADC2)
/SCL: J1.3, J2.3, J10.1, J11.1, J13.1, J14.1, R2.2, U2.2 (GPIO1)
/SDA: J1.1, J2.1, J10.2, J11.2, J13.2, J14.2, R1.2, U2.1 (GPIO0)
/SPI_CLK: U1.5 (SCK), U2.4 (GPIO2), U3.4 (SCLK)
/SPI_CS0: U1.4 (~CSN), U2.7 (GPIO5)
/SPI_CS1: U2.31 (GPIO26_ADC0), U3.5 (~SS)
/SPI_MISO: U1.7 (MISO), U2.6 (GPIO4), U3.7 (MISO)
/SPI_MOSI: U1.6 (MOSI), U2.5 (GPIO3), U3.3 (MOSI)
/STATUS_LEDS: J7.2, J12.1, U2.29 (GPIO22)
/WIZ_NRF_INT: J3.2, J3.4, J3.6, J3.8, U2.32 (GPIO27_ADC1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C8.2, C9.2, C10.2, C13.2, C14.2, C15.2, C16.2, C19.2, C21.2, C23.2, C25.2, C27.2, C29.2, J1.2, J1.8, J1.10, J1.12, J2.2, J2.10, J2.12, J5.5 (GND), J5.6 (Shield), J6.1, J7.1, J7.4, J8.1, J8.2, J8.3, J8.4, J9.1, J9.2, J9.3, J9.4, J10.4, J11.4, J12.4, J13.4, J14.4, J15.1, J15.2, J15.3, J15.4, U1.1 (GND), U2.3 (GND), U2.8 (GND), U2.13 (GND), U2.18 (GND), U2.23 (GND), U2.28 (GND), U2.33 (AGND), U2.38 (GND), U3.1 (GND), U3.2 (GND), U3.12 (GND)
unnamed: D1.2 (A), J5.1 (VBUS), J6.5
unnamed: J3.1, U2.27 (GPIO21)
unnamed: J3.7, U2.26 (GPIO20)
VDD: C2.1, C3.1, C4.1, C5.1, C9.1, C10.1, C15.1, C16.1, D1.1 (K), J1.4, J2.4, J7.3, J12.3, U2.39 (VSYS)

## KiCad design boards/Ottercast__OtterCastAudioV2__OtterCastAudioV2/unrouted.kicad_pcb

Board: 4 copper layers, 50.0 x 49.3 mm, 216 parts (7 on the bottom side), 149 nets, no tracks yet.

Parts:
AE1: KH-5220-A56_U.FL; KH-5220-A56
C1, C4, C6, C14, C16, C17, C19, C20, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C39, C41, C48, C72, C74, C90, C92, C95: 10u; C_0603
C2: 470n; C_0402
C3, C7, C8, C15, C18, C21, C32, C33, C34, C35, C36, C37, C38, C44, C58, C59, C61, C65, C66, C73, C76, C82, C83, C85, C88, C89, C98, C100, C101, C102, C103: 100n; C_0402
C5, C10, C11, C42, C43, C45: 47u; C_0805
C9: 2.2u; C_0603
C12, C47: 1n; C_0402
C13, C104: 1n; C_0805
C46, C50, C53, C70, C71: 220p; C_0402
C49: DNP; C_0402
C51, C52, C93, C94, C96, C97: 18p; C_0402
C54, C55, C56, C57, C60, C62, C63, C64, C69: 10u; CP_EIA-3216-10
C67, C68: 100u; CP_EIA-3528-12
C75, C77: 1p; C_0402
C78: 10p; C_0402
D1, D2: LED; LED_0603_1608Metric
D3: LED; LED_0603_1608Metric_Castellated
D4: P6SMB6.8CA; D_SMB
D5, D6: ESD5302F; SOT-23
FB1, FB2, FB3: FERRET; R_0805
J1: UART; PinHeader_1x04_P2.00mm_Vertical_nosilk_center
J2: SD; microSD_HC_Hirose_DM3D-SF
J3: USB; USB-C 16Pin
J4: OTG; PinHeader_1x04_P2.00mm_Vertical_nosilk_center
J5, J6, J7: PJ-3270
J8: 49F-1201GYD2NL; 49F-1201GYDXNL
L1, L2, L3, L4: 2.2uH; L_Taiyo-Yuden_MD-3030
L5: 2.2nH; L_0402
MK1: Mic; B4013AM422-42
Q1: DTA114YKA; SOT-23
R1, R32, R33, R61, R62: 100; R_0402
R2, R15, R34, R54, R76, R77, R81: 22; R_0402
R3, R4, R14, R24, R25, R30, R35, R36, R39, R86: 5k1; R_0402
R6, R22, R23, R29, R47, R52, R66, R67, R68, R69: DNP; R_0402
R7, R8, R9, R10, R11, R12, R13, R18, R26, R42, R58, R59, R60, R63, R64, R65, R70, R71, R72, R73, R74, R75: 47k; R_0402
R16, R21, R40, R78: 200k; R_0402
R17, R28, R37, R41, R48, R49, R50, R51, R79, R80, R87, R88: 2k2; R_0402
R27: 0R; R_0805
R31: 3k3; R_0402
R38: 3k9; R_0402
R43: 680; R_0402
R44, R45, R46: 0; R_0402
R82, R83: 240; R_0402
R84: 10M; R_0402
R89: 6k04; R_0402
R90, R91, R92, R93: 51; R_0402
SW3: RST; SW_SPST_PTS810
U1: AllWinner-S3(FBGA-234); FBGA-234(Pitch-0.65mm_Pad-0.3mm_11x11x1.08mm)
U3: AXP209(QFN-48); QFN-48-1EP_6x6mm_P0.4mm_EP4.05x4.05mm
U4: SY8089AAAC; SOT-23-5
U5: SY6280AAC; SOT-23-5
U6: SSM2603; LFCSP-28-5x5mm-0.5mm-EP3.14x3.14mm
U7: AP6236; LGA_44_12x12mm_0.9mm
X1: 26Mhz TCXO; 2016_SMD_CRYSTAL
Y1: 12.288Mhz; Oscillator_3225
Y2: 32.768kHz; Crystal_SMD_3215-2Pin_3.2x1.5mm
Y3: 24MHz; Oscillator_3225

Connections:
+1V1: C18.1, C22.1, C33.1, C35.1, C36.1, C39.1, C92.1, L2.2, U1.G12, U1.H12, U1.J11, U1.J12, U1.K8, U1.K9, U1.K11, U1.L8, U1.M8, U1.N5, U3.10
+1V2: C27.1, U3.41
+2V5: C7.1, U3.19
+2V8: C29.1, U3.11
+3.0VA: C26.1, C60.1, C65.1, C89.1, FB2.2, FB3.2, R40.1, U1.L6, U1.M7, U3.12, U4.1, U6.5
+3.3V_RTC: C25.1, C98.1, R18.2, R26.1, R86.2, U1.N6, U3.28, U3.29
+3V3: C1.1, C21.1, C23.1, C38.1, C62.1, C66.1, C72.1, C73.1, C74.1, C76.1, C95.1, FB1.1, J1.4, J8.9, J8.11, L1.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, R13.2, R48.2, R49.2, R50.2, R51.2, R64.1, R65.1, R70.1, R71.1, R72.1, R73.1, R74.1, R75.1, U1.H11, U1.L11, U1.L12, U1.M4, U1.M5, U1.M11, U1.M12, U1.N7, U1.P5, U1.P12, U3.17, U6.3, U7.9, U7.22, X1.4
+5V: C11.1, C14.1, C42.1, D4.1, J3.A4, J3.A9, J3.B4, J3.B9, R14.2, U3.32, U3.33, U5.5
+5V_USBOTG: C6.1, C43.1, C45.1, J4.4, R37.1, U3.31, U5.1
/Power/NMI: R18.1, U3.48
AP_CK32KO: R76.1, R86.1, U1.P3
AP_WAKE_BT: U1.F12, U7.6
BT_DIS_N: R2.2, U7.34
BT_PCM_CLK: R67.1, U1.P14, U6.7
BT_PCM_DIN: R68.1, U1.M13, U6.10
BT_PCM_DOUT: R69.1, U1.T15, U6.8
BT_PCM_SYNC: R54.2, R66.1, U1.T14, U6.9
BT_UART_CTS: U1.B8, U7.44
BT_UART_RTS: U1.C4, U7.41
BT_UART_RX: R74.2, U1.B3, U7.43
BT_UART_TX: U1.B4, U7.42
BT_WAKE_AP: R75.2, U1.N14, U7.7
EPHY_LINK_LED: R87.1, U1.K5
EPHY_RX_N: J8.2, R90.1, U1.F1
EPHY_RX_P: J8.1, R91.1, U1.F2
EPHY_SPD_LED: R88.1, U1.L5
EPHY_TX_N: J8.8, R92.1, U1.E2
EPHY_TX_P: J8.7, R93.1, U1.E3
GND: AE1.2, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.1, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C41.2, C42.2, C43.2, C44.2, C45.2, C48.2, C49.2, C51.2, C52.2, C60.2, C61.2, C62.2, C65.2, C66.2, C69.2, C72.2, C73.2, C74.2, C75.1, C76.2, C77.1, C83.2, C85.2, C88.2, C89.2, C90.2, C92.2, C93.2, C94.2, C95.2, C96.2, C97.2, C98.2, C100.1, C101.1, C102.1, C103.1, C104.2, D1.1, D2.1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
GNDA: C46.2, C50.2, C53.2, C54.2, C55.2, C58.2, C59.2, C70.2, C71.2, J5.4, J6.4, J7.4, MK1.1, R27.2, R42.2, R47.2, R52.2, R58.1, R59.2, R60.1, R63.2, U6.15, U6.19
GPIO_LED1: R3.1, U1.C7
GPIO_LED2: R4.1, U1.C8
GPIO_RST: R6.2, SW3.2, U1.A2
IPS: C5.1, C8.1, C10.1, C16.1, C17.1, C19.1, C20.1, C24.1, C28.1, C30.1, Q1.2, U3.7, U3.13, U3.14, U3.21, U3.34, U3.35, U3.40, U3.44, U4.4
MIC_DET: R40.2, R41.1, U1.B5
MIPI_SCK: R51.1, U1.G16, U3.2, U6.28
MIPI_SDA: R50.1, U1.J16, U3.1, U6.27
unnamed: AE1.1, C75.2, L5.1
unnamed: C3.1, R78.1, U1.N10
unnamed: C4.1, FB1.2, J2.4
unnamed: C9.2, U3.24
unnamed: C12.1, U3.47
unnamed: C13.1, J3.S1, R21.1
unnamed: C15.1, U3.38, U3.39, U3.42
unnamed: C46.1, C47.2, MK1.2, R42.1, R43.1
unnamed: C47.1, R46.1
unnamed: C48.1, C49.1, L4.1, U7.23
unnamed: C50.1, C57.2, R45.2, R47.1
unnamed: C51.1, U6.1, Y1.3
unnamed: C52.1, U6.2, Y1.1
unnamed: C53.1, C56.2, R44.2, R52.1
unnamed: C54.1, C58.1, FB3.1, U6.18
unnamed: C55.1, C59.1, FB2.1, U6.12
unnamed: C56.1, U6.24
unnamed: C57.1, U6.23
unnamed: C61.1, C69.1, U6.20
unnamed: C63.1, U6.17
unnamed: C63.2, R58.2, R61.2
unnamed: C64.1, U6.16
unnamed: C64.2, R60.2, R62.2
unnamed: C67.1, U6.14
unnamed: C67.2, C71.1, J6.5, R63.1
unnamed: C68.1, U6.13
unnamed: C68.2, C70.1, J6.2, R59.1
unnamed: C77.2, C78.1, L5.2
unnamed: C78.2, U7.2
unnamed: C82.1, C83.1, C88.1, R79.1, R80.1, U1.H6
unnamed: C85.1, U1.M9
unnamed: C90.1, U1.T5
unnamed: C93.1, U1.R4, Y3.1
unnamed: C94.1, U1.P4, Y3.3
unnamed: C96.1, R84.2, U1.T3, Y2.1
unnamed: C97.1, R84.1, U1.R3, Y2.2
unnamed: C100.2, R90.2, R91.2
unnamed: C101.2, R92.2, R93.2
unnamed: C102.2, J8.3
unnamed: C103.2, J8.6
unnamed: C104.1, J8.SH
unnamed: D1.2, R3.2
unnamed: D2.2, R4.2
unnamed: D3.2, R14.1
unnamed: D5.1, J1.3, R33.1
unnamed: D5.2, J1.2, R1.1
unnamed: J3.A5, R24.1
unnamed: J3.A6, J3.B6, R23.1
unnamed: J3.A7, J3.B7, R22.1
unnamed: J3.B5, R25.1
unnamed: J5.2, R44.1
unnamed: J5.3, R41.2
unnamed: J5.5, R45.1
unnamed: J7.2, R62.1
unnamed: J7.5, R61.1
unnamed: J8.10, R88.2
unnamed: J8.12, R87.2
unnamed: L1.1, U3.15
unnamed: L2.1, U3.8
unnamed: L3.1, U4.3
unnamed: L4.2, U7.21
unnamed: Q1.1, R6.1
unnamed: Q1.3, R17.1, U3.4
unnamed: R2.1, U1.C13
unnamed: R15.1, U3.37
unnamed: R16.1, U3.23
unnamed: R28.2, R29.2, U3.27
unnamed: R30.2, R31.1, U4.5
unnamed: R31.2, R32.1
unnamed: R34.1, U1.M6
unnamed: R36.1, U5.3
unnamed: R43.2, U6.21
unnamed: R46.2, U6.22
unnamed: R48.1, U6.25
unnamed: R49.1, U6.26
unnamed: R54.1, U6.11
unnamed: R66.2, U7.28
unnamed: R67.2, U7.26
unnamed: R68.2, U7.27
unnamed: R69.2, U7.25
unnamed: R76.2, U7.24
unnamed: R77.2, U7.17
unnamed: R81.1, U1.R13
unnamed: R82.1, U1.J5
unnamed: R83.1, U1.F5
unnamed: R89.2, U1.P6
unnamed: U7.10, X1.3
RESETn: C2.1, R26.2, U1.P7, U3.25
SDC0_CLK: J2.5, R10.1, U1.P2
SDC0_CMD: J2.3, R9.1, U1.N2
SDC0_D0: J2.7, R11.1, U1.P1
SDC0_D1: J2.8, R12.1, U1.R1
SDC0_D2: J2.1, R7.1, U1.M2
SDC0_D3: J2.2, R8.1, U1.N3
SDC0_DET#: J2.10, R13.1, U1.M1
UART1_RX: R1.2, U1.M14
UART1_TX: R33.2, U1.M15
USB_DRV: R35.1, U3.6, U5.4
USB_D_N: D6.2, J4.3, R22.2, U1.R2
USB_D_P: D6.1, J4.2, R23.2, U1.T2
USB_ID: R39.2, U1.R14
USB_VBUSDET: C44.1, R37.2, R38.1, U1.A5
VCC-DDR: C31.1, C32.1, C34.1, C37.1, C41.1, C82.2, L3.2, R30.1, R79.2, U1.F6, U1.F7, U1.F8, U1.G8, U1.H8, U1.J8
VINT: R28.1, U3.26
WL_PMU_EN: R73.2, U1.E16, U7.12
WL_SDIO_CLK: R77.1, U1.P16
WL_SDIO_CMD: R72.2, U1.N15, U7.16
WL_SDIO_D0: R71.2, U1.P15, U7.18
WL_SDIO_D1: R70.2, U1.N16, U7.19
WL_SDIO_D2: R65.2, U1.R15, U7.14
WL_SDIO_D3: R64.2, U1.R16, U7.15
WL_WAKE_AP: U1.C5, U7.13

## KiCad design boards/PTALTS-LK__RKD-OLD__RKD/board.kicad_pcb

Board: 2 copper layers, 100.0 x 94.0 mm, 138 parts (27 on the bottom side), 78 nets.

Parts:
C1, C2: 1u; C_0805_2012Metric
C3, C4: 27p; C_0805_2012Metric
C5, C6: 10u; C_0805_2012Metric
C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19: 100n; C_0805_2012Metric
D1, D2, D3, D4: LED; L1206
H1, H2, H3, H4, H5, H6, H7, H8, H9, H10, H11: MountingHole; HO
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2, J4: Conn_02x02_Odd_Even; PinHeader_2x02_P2.54mm_Horizontal
J3, J5: Conn_02x04_Odd_Even; PinHeader_2x04_P2.54mm_Horizontal
J6, J9: Conn_02x04_Odd_Even; PinSocket_2x04_P2.54mm_Horizontal
J7, J8: Conn_02x02_Odd_Even; PinSocket_2x02_P2.54mm_Horizontal
J10: Conn_01x04_Male; XH-7mm
J11: Conn_02x06_Odd_Even; PinHeader_2x06_P2.54mm_Vertical
J12: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
J13: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J14, J15: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
K1, K2, K3, K4, K5, K6: Key
R1, R2, R5, R6, R7, R8, R10, R11: 27; R_0805_2012Metric
R3, R15: 1k; R_0805_2012Metric
R4: 4.7k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R9, R12: 0; R_0805_2012Metric
R13, R14, R16, R17: 1k 0805; R_0805_2012Metric
R18: 4.7k 0805; R_0805_2012Metric
R19, R20: 5.1k; R_0805_2012Metric
SW2: SW_DIP_x04; SW_DIP_SPSTx04_Slide_9.78x12.34mm_W7.62mm_P2.54mm
SW3, SW5: SW_Push; SW_Push_1P1T_NO_6x6mm_H9.5mm
SW6, SW8: RotaryEncoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
SW7: SW_Push; SW_PUSH-12mm_Wuerth-430476085716
U1: W25Q32JV; SOIC-8_5.23x5.23mm_P1.27mm
U2: RP2040; RP2040-QFN-56
U3: CH9329; SOIC-16_3.9x9.9mm_P1.27mm
U4: AP1117-33; SOT-223-3_TabPin2
Y1: Crystal 12MHZ HC49; Crystal_SMD_HC49-SD
kibuzzard-63A1C2D7: G***; kibuzzard-63A1C2D7
kibuzzard-64E6F17C: G***; kibuzzard-64E6F17C
kibuzzard-635D2D2A: G***; kibuzzard-635D2D2A
kibuzzard-635D2D3A: G***; kibuzzard-635D2D3A
kibuzzard-635D2D4F: G***; kibuzzard-635D2D4F
kibuzzard-635D2D9C: G***; kibuzzard-635D2D9C
kibuzzard-635D2DDA: G***; kibuzzard-635D2DDA
kibuzzard-635D2DF8: G***; kibuzzard-635D2DF8
kibuzzard-635D2E5E: G***; kibuzzard-635D2E5E
kibuzzard-635D2E8C: G***; kibuzzard-635D2E8C
kibuzzard-635E2F9D: G***; kibuzzard-635E2F9D
kibuzzard-6354EA44: G***; kibuzzard-6354EA44
kibuzzard-6354EB36: G***; kibuzzard-6354EB36
kibuzzard-6354EB60: G***; kibuzzard-6354EB60
kibuzzard-6354ECAF: G***; kibuzzard-6354ECAF
kibuzzard-6354ECBE: G***; kibuzzard-6354ECBE
kibuzzard-6354ECDD: G***; kibuzzard-6354ECDD
kibuzzard-6354F0BA: G***; kibuzzard-6354F0BA
kibuzzard-6354F0CA: G***; kibuzzard-6354F0CA
kibuzzard-6354F005: G***; kibuzzard-6354F005
kibuzzard-6354F197: G***; kibuzzard-6354F197
kibuzzard-6358CBD1: G***; kibuzzard-6358CBD1
kibuzzard-6358CBDF: G***; kibuzzard-6358CBDF
kibuzzard-6358CBEF: G***; kibuzzard-6358CBEF
kibuzzard-6358CC01: G***; kibuzzard-6358CC01
kibuzzard-6358CC12: G***; kibuzzard-6358CC12
kibuzzard-6379A323: G***; kibuzzard-6379A323
kibuzzard-6379AB1D: G***; kibuzzard-6379AB1D
kibuzzard-6379AB44: G***; kibuzzard-6379AB44
kibuzzard-6379ABBC: G***; kibuzzard-6379ABBC
kibuzzard-6379ABEB: G***; kibuzzard-6379ABEB
kibuzzard-6379AC10: G***; kibuzzard-6379AC10
kibuzzard-6379AC21: G***; kibuzzard-6379AC21
kibuzzard-6379AD0A: G***; kibuzzard-6379AD0A
kibuzzard-6379AD2A: G***; kibuzzard-6379AD2A
kibuzzard-6379AD8B: G***; kibuzzard-6379AD8B
kibuzzard-6379AD17: G***; kibuzzard-6379AD17
kibuzzard-6379AD65: G***; kibuzzard-6379AD65
kibuzzard-6379AD71: G***; kibuzzard-6379AD71
kibuzzard-6379AD90: G***; kibuzzard-6379AD90
kibuzzard-6379AEA3: G***; kibuzzard-6379AEA3
kibuzzard-6379AEAA: G***; kibuzzard-6379AEAA
kibuzzard-6379AEAF: G***; kibuzzard-6379AEAF
kibuzzard-6379AEB5: G***; kibuzzard-6379AEB5
kibuzzard-6379AEB9: G***; kibuzzard-6379AEB9
kibuzzard-6379AEBD: G***; kibuzzard-6379AEBD
kibuzzard-6379AEE6: G***; kibuzzard-6379AEE6
kibuzzard-6379B2A2: G***; kibuzzard-6379B2A2
kibuzzard-6379B2B1: G***; kibuzzard-6379B2B1
kibuzzard-6379B2D0: G***; kibuzzard-6379B2D0
kibuzzard-6379B2D8: G***; kibuzzard-6379B2D8
kibuzzard-6379B29B: G***; kibuzzard-6379B29B

Connections:
+1V1: C1.2, C7.2, C8.2, U2.23 (DVDD), U2.45 (VREG_VOUT), U2.50 (DVDD)
+3V3: C2.1, C6.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, J4.1, J11.1, J12.6, R13.2, R14.2, SW2.8, U1.8 (VCC), U2.1 (IOVDD), U2.10 (IOVDD), U2.22 (IOVDD), U2.33 (IOVDD), U2.42 (IOVDD), U2.43 (ADC_AVDD), U2.44 (VREG_IN), U2.48 (USB_VDD), U2.49 (IOVDD), U3.15 (VCC), U3.16 (V33), U4.2 (VO)
/22: J3.3, J11.11, U2.34 (GPIO22)
/23: J3.5, J11.9, U2.35 (GPIO23)
/24: J5.1, J12.4, U2.36 (GPIO24)
/25: J12.3, U2.37 (GPIO25)
/26: J3.7, J11.7, U2.38 (GPIO26_ADC0)
/27: J11.5, U2.39 (GPIO27_ADC1)
/28: J5.3, J12.2, U2.40 (GPIO28_ADC2)
/29: J5.5, J12.1, U2.41 (GPIO29_ADC3)
/ACT: D1.1 (K), U3.1 (ACT#)
/BOOT: R15.2, U1.1 (~CS), U2.56 (QSPI_SS)
/D+: J1.A6 (D+), J1.B6 (D+), R12.1, U3.12 (UD+)
/D-: J1.A7 (D-), J1.B7 (D-), R9.1, U3.13 (UD-)
/DEF: U2.7 (GPIO5), U3.10 (DEF)
/F1: J11.8, SW2.7, U2.8 (GPIO6)
/F2: J11.6, SW2.6, U2.9 (GPIO7)
/F3: J11.4, SW2.5, U2.11 (GPIO8)
/F-CLK: U1.6 (CLK), U2.52 (QSPI_SCLK)
/K1: J14.2, K1.2 (IO+), K1.4 (L-), U2.12 (GPIO9)
/K2: J14.3, K2.2 (IO+), K2.4 (L-), U2.13 (GPIO10)
/K3: J15.2, K3.2 (IO+), K3.4 (L-), U2.14 (GPIO11)
/K4: J15.3, K4.2 (IO+), K4.4 (L-), U2.15 (GPIO12)
/K5-H: J2.3, U2.17 (GPIO14)
/K5-S: J8.3, K5.2 (IO+), K5.4 (L-)
/K6-H: J2.1, U2.18 (GPIO15)
/K6-S: J8.1, K6.2 (IO+), K6.4 (L-)
/L1: K1.3 (L+), R5.1
/L2: K2.3 (L+), R6.1
/L3: K3.3 (L+), R7.1
/L4: K4.3 (L+), R8.1
/L5: K5.3 (L+), R10.2
/L6: K6.3 (L+), R11.2
/LED: J3.1, J4.3, J5.7, R5.2, R6.2, R7.2, R8.2, SW2.1
/LED-S: J7.3, R10.1, R11.1
/MODE: J11.10, R17.2, U2.5 (GPIO3)
/PRESS: J11.12, R16.2, U2.4 (GPIO2)
/R+: R1.2, U2.47 (USB_DP)
/R-: R2.1, U2.46 (USB_DM)
/RA1-H: J3.8, U2.27 (GPIO16)
/RA1-S: C16.1, J6.8, SW6.A
/RA2-H: J5.6, U2.30 (GPIO19)
/RA2-S: C18.1, J9.6, SW8.A
/RB1-H: J3.6, U2.28 (GPIO17)
/RB1-S: C17.2, J6.6, SW6.B
/RB2-H: J5.4, U2.31 (GPIO20)
/RB2-S: C19.2, J9.4, SW8.B
/RP+: J10.3, R1.1, R12.2
/RP-: J10.2, R2.2, R9.2
/RS1-H: J3.4, U2.29 (GPIO18)
/RS1-S: J6.4, SW6.S1
/RS2-H: J5.2, U2.32 (GPIO21)
/RS2-S: J9.2, SW8.S1
/RUN: J11.2, SW5.2, U2.26 (RUN)
/SEL-H: J2.4, U2.16 (GPIO13)
/SEL-S: J8.4, SW7.2
/SET: U2.6 (GPIO4), U3.11 (SET)
/TR+: U2.3 (GPIO1), U3.7 (TXD)
/TR-: U2.2 (GPIO0), U3.8 (RXD)
/XIN: C3.2, U2.20 (XIN), Y1.2
/XOUT: R3.2, U2.21 (XOUT)
GND: C1.1, C2.2, C3.1, C4.1, C5.2, C6.2, C7.1, C8.1, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.1, C18.2, C19.1, D2.1 (K), D3.1 (K), D4.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.2, J3.2, J4.2, J4.4, J5.8, J6.2, J8.2, J9.8, J10.4, J11.3, J12.5, J13.2, J14.1, J14.4, J15.1, J15.4, K1.1 (GND), K2.1 (GND), K3.1 (GND), K4.1 (GND), K5.1 (GND), K6.1 (GND), R4.2, R18.2, R19.2, R20.2, SW2.2, SW2.3, SW2.4, SW3.1, SW5.1, SW6.C, SW6.S2, SW7.1, SW8.C, SW8.S2, U1.4 (GND), U2.19 (TESTEN), U2.57 (GND), U3.14 (GND), U4.1 (GND)
unnamed: C4.2, R3.1, Y1.1
unnamed: D1.2 (A), R14.1
unnamed: D2.2 (A), R16.1
unnamed: D3.2 (A), R13.1
unnamed: D4.2 (A), R17.1
unnamed: J13.1, U2.25 (SWD)
unnamed: J13.3, U2.24 (SWCLK)
unnamed: R15.1, SW3.2
unnamed: R4.1, R18.1, U3.9 (UP)
unnamed: J1.A5 (CC1), R19.1
unnamed: J1.B5 (CC2), R20.1
unnamed: U1.2 (DO(IO1)), U2.55 (QSPI_SD1)
unnamed: U1.3 (IO2), U2.54 (QSPI_SD2)
unnamed: U1.5 (DI(IO0)), U2.53 (QSPI_SD0)
unnamed: U1.7 (IO3), U2.51 (QSPI_SD3)
VBUS: C5.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J10.1, U4.3 (VI)

## KiCad design boards/Pakequis__Bad-Thing-of-the-Edge-keyboard__Bad_Thing_of_the_Edge_Keyboard/unrouted.kicad_pcb

Board: 2 copper layers, 118.6 x 145.8 mm, 61 parts (0 on the bottom side), 46 nets, no tracks yet.

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1, J2, J3, J4, J5, J6: Conn_01x01_Pin; MountingHole_3.2mm_M3_Pad
Q1, Q2, Q3, Q4: BSS138; SOT-23
R1, R4, R7, R10: 47R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R5, R8, R11: 100R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R6, R9, R12: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20: SW_Push; SW_Cherry_MX_1.00u_PCB
U1: Pico; RPi_Pico_SMD_TH
m1: OSHW-Logo2_14.6x12mm_SilkScreen
m2: KiCad-Logo2_5mm_SilkScreen

Connections:
GNDREF: J1.1, J2.1, J3.1, J4.1, J5.1, J6.1, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), R3.2, R6.2, R9.2, R12.2, SW1.1, SW2.1, SW3.1, SW4.1, SW5.1, SW6.1, SW7.1, SW8.1, SW9.1, SW10.1, SW11.2, SW12.2, SW13.2, SW14.2, SW15.2, SW16.2, SW17.2, SW18.2, SW19.2, SW20.2, U1.3 (GND), U1.8 (GND), U1.13 (GND), U1.18 (GND), U1.23 (GND), U1.28 (GND), U1.33 (AGND), U1.38 (GND), U1.42 (GND)
unnamed: D1.2 (A), D3.2 (A), R1.2
unnamed: D1.1 (K), D2.2 (A)
unnamed: D2.1 (K), D4.1 (K), Q1.3 (D)
unnamed: D3.1 (K), D4.2 (A)
unnamed: D5.2 (A), D7.2 (A), R4.2
unnamed: D5.1 (K), D6.2 (A)
unnamed: D6.1 (K), D8.1 (K), Q2.3 (D)
unnamed: D7.1 (K), D8.2 (A)
unnamed: D9.1 (K), D10.2 (A)
unnamed: D10.1 (K), D12.1 (K), Q3.3 (D)
unnamed: D9.2 (A), D11.2 (A), R7.2
unnamed: D11.1 (K), D12.2 (A)
unnamed: D13.2 (A), D15.2 (A), R10.2
unnamed: D13.1 (K), D14.2 (A)
unnamed: D14.1 (K), D16.1 (K), Q4.3 (D)
unnamed: D15.1 (K), D16.2 (A)
unnamed: Q1.1 (G), R2.2, R3.1
unnamed: Q2.1 (G), R5.2, R6.1
unnamed: Q3.1 (G), R8.2, R9.1
unnamed: Q4.1 (G), R11.2, R12.1
unnamed: R2.1, U1.1 (GPIO0)
unnamed: SW2.2, U1.2 (GPIO1)
unnamed: SW3.2, U1.4 (GPIO2)
unnamed: SW4.2, U1.5 (GPIO3)
unnamed: SW5.2, U1.6 (GPIO4)
unnamed: SW6.2, U1.7 (GPIO5)
unnamed: SW11.1, U1.9 (GPIO6)
unnamed: SW1.2, U1.10 (GPIO7)
unnamed: SW7.2, U1.12 (GPIO9)
unnamed: SW8.2, U1.14 (GPIO10)
unnamed: R11.1, U1.15 (GPIO11)
unnamed: SW9.2, U1.16 (GPIO12)
unnamed: SW10.2, U1.17 (GPIO13)
unnamed: SW20.1, U1.19 (GPIO14)
unnamed: R8.1, U1.21 (GPIO16)
unnamed: SW19.1, U1.22 (GPIO17)
unnamed: SW18.1, U1.24 (GPIO18)
unnamed: SW17.1, U1.25 (GPIO19)
unnamed: SW16.1, U1.26 (GPIO20)
unnamed: SW15.1, U1.27 (GPIO21)
unnamed: SW14.1, U1.29 (GPIO22)
unnamed: SW13.1, U1.31 (GPIO26_ADC0)
unnamed: SW12.1, U1.32 (GPIO27_ADC1)
unnamed: R5.1, U1.34 (GPIO28_ADC2)
VBUS: R1.1, R4.1, R7.1, R10.1, U1.40 (VBUS)
