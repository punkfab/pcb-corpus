# Repository punkfab/pcb-corpus

## KiCad design boards/GuitarML__FunBox__funbox_v2/unrouted.kicad_pcb

Board: 2 copper layers, 59.7 x 67.5 mm, 70 parts (0 on the bottom side), 54 nets, no tracks yet.

Parts:
9v: TestPoint_THTPad_D2.0mm_Drill1.0mm
A1: Electrosmith_Daisy_Seed_Rev4; Electrosmith_Daisy_Seed
C1, C4, C5, C14, C15, C17: 1UF; C_Rect_L7.0mm_W6.0mm_P5.00mm
C2, C11: 100pF; C_Rect_L7.0mm_W2.5mm_P5.00mm
C3, C16: 1NF; C_Rect_L7.0mm_W2.5mm_P5.00mm
C6: 100UF; CP_Radial_D8.0mm_P3.50mm
C7, C8, C9, C10: 100NF; C_Rect_L7.0mm_W2.5mm_P5.00mm
C12, C13: 2.2nF; C_Rect_L7.0mm_W2.5mm_P5.00mm
C30: 100NF; C_Disc_D6.0mm_W2.5mm_P5.00mm
D1: 1N5817; D_DO-41_SOD81_P7.62mm_Horizontal
D2: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
DipSwitch: DS03-254-04BE; DS03-254-04BE-dip4
FS1: Foot_Switch_1; PinHeader_1x02_P2.54mm_Vertical
FS2: Foot_Switch_2; PinHeader_1x02_P2.54mm_Vertical
Gnd: TestPoint_THTPad_D2.0mm_Drill1.0mm
InG: TestPoint_THTPad_D2.0mm_Drill1.0mm
InL: TestPoint_THTPad_D2.0mm_Drill1.0mm
InR: TestPoint_THTPad_D2.0mm_Drill1.0mm
J6: MIDI IN; TRRS-PJ-320A
J7: MIDI OUT; TRRS-PJ-320A
LED1: LED_1; PinHeader_1x02_P2.54mm_Vertical
LED2: LED_2; PinHeader_1x02_P2.54mm_Vertical
OutG: TestPoint_THTPad_D2.0mm_Drill1.0mm
OutL: TestPoint_THTPad_D2.0mm_Drill1.0mm
OutR: TestPoint_THTPad_D2.0mm_Drill1.0mm
POT1, POT2, POT3, POT4, POT5, POT6: 10K; Pot_RightAngle_LongPin_16mm
R1, R2, R5, R6, R13, R14, R15, R16: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3, R8, R9, R12: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4, R17: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R7, R18: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R10, R11: 3K3; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R30: 220R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R31: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R32: 10R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R33: 33R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1, SW2, SW3: SW_SPDT; SW_Toggle_SPDT_lugs
U1: TL074; DIP-14_W7.62mm
U2: L7805; TO-220-3_Vertical
U5: H11L1; DIP-6_W7.62mm

Connections:
3V3_A: A1.21 (3V3_A), C30.1, POT1.3, POT2.3, POT3.3, POT4.3, POT5.3, POT6.3, R31.1, R33.2, U5.6
5V: C9.2, C10.2, R2.1, R5.1, R13.1, R15.1, U1.4 (V+), U2.3 (OUT)
AUDIO_IN_BUFFER_LEFT: A1.16 (AUDIO_IN_1), U1.1, U1.2 (-)
AUDIO_IN_BUFFER_RIGHT: A1.17 (AUDIO_IN_2), U1.8, U1.9 (-)
AUDIO_OUT_BUFFER_LEFT: A1.18 (AUDIO_OUT_1), R11.1
AUDIO_OUT_BUFFER_RIGHT: A1.19 (AUDIO_OUT_2), R10.1
DIP1: A1.2 (SD_DATA_3), DipSwitch.1A
DIP2: A1.4 (SD_DATA_1), DipSwitch.2A
DIP3: A1.6 (SD_CMD), DipSwitch.3A
DIP4: A1.7 (SD_CLK), DipSwitch.4A
FOOT_SWITCH_1: A1.32 (SAI2_SD_B), FS1.2
FOOT_SWITCH_2: A1.33 (SAI2_SD_A), FS2.2
GND: A1.20 (AGND), A1.40 (DGND), C2.2, C3.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.2, C12.2, C13.2, C16.1, C30.2, DipSwitch.1B, DipSwitch.2B, DipSwitch.3B, DipSwitch.4B, FS1.1, FS2.1, Gnd.1, InG.1, J6.S, J7.S, LED1.1 (K), LED2.1 (K), OutG.1, POT1.1, POT2.1, POT3.1, POT4.1, POT5.1, POT6.1, R1.2, R6.2, R7.1, R14.2, R16.2, R18.1, SW1.2 (B), SW2.2 (B), SW3.2 (B), U1.11 (V-), U2.2 (GND), U5.5
LED_1: A1.29 (DAC_OUT2), R8.2
LED_2: A1.30 (DAC_OUT1), R9.2
MIDI_IN: A1.37 (USB_D_+), R31.2, U5.4
MIDI_IN_JACK_PIN4: J6.R1, R30.1
MIDI_IN_JACK_PIN5: D2.2 (A), J6.T, U5.2
MIDI_OUT: A1.36 (USB_D_-), R32.2
MIDI_OUT_JACK_PIN4: J7.R1, R33.1
MIDI_OUT_JACK_PIN5: J7.T, R32.1
unnamed: 9v.1, D1.2 (A)
unnamed: C1.2, R3.1
unnamed: C5.2, R4.2
unnamed: C4.1, C12.1, R11.2
unnamed: C13.1, C15.1, R10.2
unnamed: C14.2, R12.1
unnamed: C17.2, R17.2
unnamed: D2.1 (K), R30.2, U5.1
unnamed: C1.1, C2.1, InL.1
unnamed: C11.1, C14.1, InR.1
unnamed: LED1.2 (A), R8.1
unnamed: LED2.2 (A), R9.1
unnamed: C5.1, OutL.1, R7.2
unnamed: C17.1, OutR.1, R18.2
unnamed: C3.2, R1.1, R2.2, R3.2, U1.3 (+)
unnamed: C4.2, R5.2, R6.1, U1.5 (+)
unnamed: R4.1, U1.6 (-), U1.7
unnamed: C16.2, R12.2, R15.2, R16.1, U1.10 (+)
unnamed: C15.2, R13.2, R14.1, U1.12 (+)
unnamed: R17.1, U1.13 (-), U1.14
POT_1: A1.23 (ADC_1), POT1.2
POT_2: A1.24 (ADC_2), POT2.2
POT_3: A1.25 (ADC_3), POT3.2
POT_4: A1.26 (ADC_4), POT4.2
POT_5: A1.27 (ADC_5), POT5.2
POT_6: A1.28 (ADC_6), POT6.2
SW1_LEFT: A1.15 (USART1_RX), SW1.3 (C)
SW1_RIGHT: A1.14 (USART1_TX), SW1.1 (A)
SW2_LEFT: A1.8 (SPI1_CS), SW2.3 (C)
SW2_RIGHT: A1.11 (SPI1_PICO), SW2.1 (A)
SW3_LEFT: A1.3 (SD_DATA_2), SW3.3 (C)
SW3_RIGHT: A1.5 (SD_DATA_0), SW3.1 (A)
VCC: A1.39 (VIN), C6.2, C7.2, C8.2, D1.1 (K), U2.1 (IN)

## KiCad design boards/GuitarML__GuitarPedalSTM32__STM32H7_GuitarPedal/unrouted.kicad_pcb

Board: 4 copper layers, 60.0 x 95.0 mm, 101 parts (7 on the bottom side), 73 nets, no tracks yet.

Parts:
C1, C2, C15, C49, C50, C55, C56: 2.2u; C_0805_2012Metric
C3, C17, C21, C27, C34, C37, C41: 10UF; C_0805_2012Metric
C5, C7, C8, C9, C10, C12, C13, C14, C16, C30, C35, C47, C48, C57, C58: 100n; C_0603_1608Metric
C6, C11: 1u; C_0603_1608Metric
C26, C31, C32, C39, C40: 100NF; C_0805_2012Metric
C28: 3u3; C_0805_2012Metric
C36: 47UF; C_0805_2012Metric
C43, C44: 10p; C_0603_1608Metric
C45, C46: 100u 35V; CP_Elec_6.3x7.7
C52: 220p; C_0805_2012Metric
C53: 2N7; C_0805_2012Metric
D1: 1N5817; D_SOD-123
D2: 1N4007; D_SOD-123F
D3: ASMB-MTB0-0A3A2; LED_D5.0mm-4_RGB
FB1, FB2: 600Ω@100MHz; L_0805_2012Metric
FB3: 200Ω@100MHz; L_0805_2012Metric
FS1: Foot_Switch_1; PinHeader_1x02_P2.54mm_Vertical
FS2: Foot_Switch_2; PinHeader_1x02_P2.54mm_Vertical
J1: AUDIO_IN_TRS; NEUTRIK_NMJ6HCD2
J2: AUDIO_OUT_TRS; NEUTRIK_NMJ6HCD2
J3: Barrel_Jack_Switch; Generic_PowerJack
J5: EXPRESSION JACK; NEUTRIK_NMJ6HCD2
JP1: M05X2MINIJTAG; 20021121-00010C4LF_JTAG
K1: G6K-2; Relay_DPDT_Omron_G6K-2G-Y
LED1: LED_1; PinHeader_1x02_P2.54mm_Vertical
LED2: LED_2; PinHeader_1x02_P2.54mm_Vertical
POT1, POT2, POT3, POT4, POT5, POT6: 10K; Pot_RightAngle_LongPin_16mm
Q1: SS8050; SOT-23-3
R1, R22, R25: 1K; R_0805_2012Metric
R2: 10k; R_0805_2012Metric
R5, R6: 2.2k; R_0603_1608Metric
R7: 470R; R_0805_2012Metric
R10, R13, R17, R18, R23, R33: 2M; R_0805_2012Metric
R11, R14: 100K; R_0805_2012Metric
R15, R26: 1k5; R_0805_2012Metric
R16, R27, R28: 5k1; R_0603_1608Metric
R21: 100R; R_0805_2012Metric
R31, R32: 2K; R_0805_2012Metric
SW3, SW4: SW_SPDT; SW_Toggle_SPDT_lugs
U1: LD1117S50TR_SOT223; SOT-223-3_TabPin2
U2, U6: MCP6002; SOIC-8_3.9x4.9mm_P1.27mm
U3: OPA1652AID; SOIC-8_3.9x4.9mm_P1.27mm
U4: CS4270; TSSOP-24_4.4x7.8mm_P0.65mm
U7: TLV76733QWDRBxQ1; VSON-8-1EP_3x3mm_P0.65mm_EP1.65x2.4mm
U8: CPC1018N; SOP-4_3.8x4.1mm_P2.54mm
U9: STM32H7B0VBTx; LQFP-100_14x14mm_P0.5mm
Y1: Crystal_GND24 16Mhz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3V3: C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C15.1, C30.1, C48.1, C50.1, C57.1, FB3.1, JP1.1, R5.2, R6.2, U4.5 (VD), U4.8 (VLC), U7.1 (OUT), U7.3 (SNS), U9.6 (VBAT), U9.11 (VDD), U9.27 (VDD), U9.50 (VDD), U9.75 (VDD), U9.100 (VDD)
+3V3_A: C14.1, C47.1, C58.1, FB3.2, POT1.3, POT2.3, POT3.3, POT4.3, POT5.3, POT6.3, U6.3 (+), U9.20 (VREF+), U9.21 (VDDA)
+5V: C5.1, C6.1, C31.1, C32.1, C39.1, C40.1, C55.1, D2.1 (K), FB2.2, K1.1, R11.1, R17.1, U2.8 (V+), U3.8 (V+), U4.19 (VA)
+5V_exp: C27.1, C56.1, FB2.1, U1.2 (VO), U6.8 (V+)
+9V: C26.1, C46.1, C49.1, FB1.2, U1.3 (VI), U7.5 (EN), U7.8 (IN)
/Audio Input Buffer/V_AUDIOBIAS: R13.1, U2.1, U2.2 (-)
/CODEC_RST: U4.14 (~RST), U9.91 (PB5)
/I2C_SCL: R5.1, U4.10 (SCL/CCLK/M0), U9.92 (PB6)
/I2C_SDA: R6.1, U4.9 (SDA/CDOUT/M1), U9.93 (PB7)
/I2S_LRCK: U4.2 (LRCLK), U9.3 (PE4)
/I2S_MCK: U4.3 (MCLK), U9.1 (PE2)
/I2S_SCK: U4.4 (SCLK), U9.4 (PE5)
/I2S_SIN: U4.1 (SDIN), U9.5 (PE6)
/I2S_SOUT: U4.7 (SDOUT), U9.2 (PE3)
/JTCK: JP1.4, U9.76 (PA14)
/JTDI: JP1.8, U9.77 (PA15)
/JTDO: JP1.6, U9.89 (PB3)
/JTMS: JP1.2, U9.72 (PA13)
/RESET: JP1.10, U9.14 (NRST)
AUDIO_IN_BUFFER_LEFT: C21.2, C52.2, U4.15 (AINA)
AUDIO_IN_JACK_LEFT: J1.T, K1.4, K1.7
AUDIO_OUT_BUFFER_LEFT: C28.1, U4.22 (OUTA)
AUDIO_OUT_JACK_LEFT: J2.T, K1.6, U8.4
BYPASS_LEFT_RETURN: C41.2, K1.5, R23.1
BYPASS_LEFT_SEND: C34.1, K1.3, R10.1
DISABLE_AUDIO_BYPASS: R1.1, U9.81 (PD0)
ENABLE_AUDIO_MUTE: R22.1, U9.83 (PD2)
EXPRESSION_IN: U6.6 (-), U6.7, U9.29 (PA5)
EXPRESSION_IN_JACK: J5.T, R33.1, U6.5 (+)
EXPRESSION_REF: J5.R, U6.1, U6.2 (-)
FOOT_SWITCH_1: FS1.2, U9.79 (PC11)
GND: C1.2, C2.2, C3.1, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C26.2, C27.2, C30.2, C31.2, C32.2, C35.2, C36.2, C39.2, C40.2, C43.1, C44.1, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C52.1, C53.2, C55.2, C56.2, C57.2, C58.2, D3.1 (A), FS1.1, FS2.1, J1.R, J1.RN, J1.S, J1.SN, J1.TN, J2.R, J2.RN, J2.S, J2.SN, J2.TN, J3.1, J3.3, J5.RN, J5.S, J5.SN, J5.TN, JP1.3, JP1.5, JP1.9, K1.2, LED1.1 (K), LED2.1 (K), POT1.1, POT2.1, POT3.1, POT4.1, POT5.1, POT6.1, Q1.2 (E), R2.2, R10.2, R14.2, R16.2, R18.2, R23.2, R27.2, R28.2, R32.2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
LED_B: R15.1, U9.70 (PA11)
LED_B_ALT: D3.4 (BK), LED1.2 (A), R15.2
LED_G: R26.1, U9.68 (PA9)
LED_G_ALT: D3.3 (GK), LED2.2 (A), R26.2
LED_R: FS2.2, R25.1, U9.67 (PA8)
unnamed: C1.1, U9.73 (VCAP)
unnamed: C2.1, U9.48 (VCAP)
unnamed: C21.1, R31.2, R32.1
unnamed: C28.2, R2.1, R7.1
unnamed: C37.2, C53.1, R7.2
unnamed: C41.1, R21.2
unnamed: C45.1, D1.1 (K), FB1.1
unnamed: D2.2 (A), K1.8, Q1.3 (C)
unnamed: D3.2 (RK), R25.2
unnamed: Q1.1 (B), R1.2
unnamed: R22.2, U8.1
unnamed: R11.2, R14.1, U2.3 (+)
unnamed: C34.2, R13.2, U2.5 (+)
unnamed: R31.1, U2.6 (-), U2.7
unnamed: U3.1, U3.2 (-)
unnamed: C37.1, R17.2, R18.1, U3.5 (+)
unnamed: R21.1, U3.6 (-), U3.7
unnamed: R16.1, U4.11 (AD0/~CS/I2S/~LJ)
unnamed: R27.1, U4.12 (AD1/CDIN/MDIV1)
unnamed: R28.1, U4.13 (AD2/MDIV2)
unnamed: C3.2, U4.16 (AINB)
unnamed: C35.1, C36.1, U4.18 (FIL+)
unnamed: C16.1, C17.1, U4.17 (VQ)
unnamed: C44.2, U9.12 (PH0), Y1.1
unnamed: C43.2, U9.13 (PH1), Y1.3
POT_1: POT1.2, U9.35 (PB1)
POT_2: POT2.2, U9.34 (PB0)
POT_3: POT3.2, U9.33 (PC5)
POT_4: POT4.2, U9.32 (PC4)
POT_5: POT5.2, U9.31 (PA7)
POT_6: POT6.2, U9.30 (PA6)
POWER_JACK_PWR: D1.2 (A), J3.2
SW1_LEFT: SW3.3 (C), U9.25 (PA3)
SW1_RIGHT: SW3.1 (A), U9.39 (PE9)
SW2_LEFT: SW4.3 (C), U9.41 (PE11)
SW2_RIGHT: SW4.1 (A), U9.43 (PE13)

## KiCad design boards/Hydra-Designs__project-hydra-meshtastic-pcb__Hydra_Base/unrouted.kicad_pcb

Board: 2 copper layers, 72.4 x 83.8 mm, 9 parts (0 on the bottom side), 11 nets, no tracks yet.

Parts:
BT1: Battery; BatteryHolder_MPD_BH-18650-PC2
J1, J5: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J2: Screw_Terminal_01x02; TerminalBlock_Altech_AK300-2_P5.00mm
J3: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J4: Conn_01x02; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
R1, R2: R; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
U1: Hydra_Core; Hydra_core

Connections:
+5V: J2.1, U1.14 (+5V)
GND: BT1.2 (-), J1.2, J2.2, J3.2, J4.2, J5.2, R2.2, U1.11 (GND), U1.17 (GND)
unnamed: BT1.1 (+), J4.1, R1.1
unnamed: J1.1, U1.1 (+3.3V)
unnamed: J3.1, U1.3 (USR_BTN)
unnamed: R1.2, R2.1, U1.4 (VBATT)
unnamed: J1.3, U1.6 (SCL)
unnamed: J1.4, U1.7 (SDA)
unnamed: J5.1, U1.8 (GPS_PWR)
unnamed: J5.3, U1.9 (GPS_RX)
unnamed: J5.4, U1.10 (GPS_TX)

## KiCad design boards/Hydra-Designs__project-hydra-meshtastic-pcb__meshtastic-diy/unrouted.kicad_pcb

Board: 2 copper layers, 28.0 x 46.2 mm, 47 parts (4 on the bottom side), 49 nets, no tracks yet.

Parts:
C1, C2, C4, C5, C6: 100n; C_0603_1608Metric
C3, C10, C11, C12, C13: 22uF; C_0603_1608Metric
D1: LED; LED_0603_1608Metric
H1, H2, H3: tooling_hole; jlc_toolinghole
J1: programming header; PinHeader_1x08_P2.54mm_Vertical
J2: oled/gps/external HW; PinHeader_1x11_P2.54mm_Vertical
J4: ipex antenna; U.FL_Molex_MCRF_73412-0110_horizontal
L2: 4.7uH; chilsin_BMRA00040412
NT1: Net-Tie_2; NetTie-2_SMD_Pad0.5mm
Q1, Q2, Q4: BC848; SOT-23
Q5: CJ2301; SOT-23
R1, R8: 470; R_0603_1608Metric
R2, R10, R11, R16: 0; R_0603_1608Metric
R3, R4, R5, R6, R7, R9, R12, R15, R17: 10k; R_0603_1608Metric
R13: 536k; R_0603_1608Metric
R14: 118k; R_0603_1608Metric
SYM1: Meshtastic Logo; meshtastic_logo
TP1, TP2: TestPoint; TestPoint_Pad_D1.0mm
U1: ESP32-WROOM-32U
U2: ESP-PSRAM64; SOIC-8_3.9x4.9mm_P1.27mm
U3: E22-900M30S; e22-900m30s-handsoldering
U5: PAM2312; SOT-23-5

Connections:
+3V3: C2.1, C3.1, C4.1, C11.1, C12.1, J2.1, L2.2, R5.2, R6.2, R7.1, R9.2, R10.2, R13.1, U1.2, U2.8
+5V: C5.1, C10.1, C13.1, J1.3, R11.2, U3.9, U3.10, U5.1, U5.4
/5V_pwrctrl: J2.5, U1.10
/DTR: J1.1, Q1.2, R4.1
/EN: C1.1, J1.7, Q2.3, R7.2, U1.3
/ESP32_RX: R1.1, U1.34
/ESP32_TX: R2.1, U1.35
/GPIO0: J1.8, Q1.3, R5.1, U1.25
/GPIO2: D1.2, U1.24
/GPIO16: R6.1, U1.27, U2.1
/GPS_PWR_enable: R12.1, R16.2, R17.2, U1.26
/GPS_RX: J2.9, U1.14
/GPS_TX: J2.10, U1.23
/GPS_pwr: J2.8, Q5.3, R16.1
/RTS: J1.2, Q2.2, R3.1
/SCL: J2.6, U1.36
/SDA: J2.7, U1.33
/SDI_SD1: U1.22, U2.5
/SDO_SD0: U1.21, U2.2
/SHD_SD2: U1.17, U2.7
/SRAM_CLK: U1.28, U2.6
/SWP_SD3: U1.18, U2.3
/USR_BTN: J2.3, R9.1, U1.5
/e22_BUSY: U1.8, U3.14
/e22_DIO1: U1.9, U3.13
/e22_MISO: U1.31, U3.16
/e22_MOSI: U1.12, U3.17
/e22_NRST: U1.37, U3.15
/e22_NSS: U1.30, U3.19
/e22_RXEN: U1.13, U3.6
/e22_SCK: U1.29, U3.18
/e22_TXEN: U1.16, U3.7
/gpio_26: J2.2, U1.11
/vbat_mon: C6.1, J2.4, U1.7
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C13.2, J1.6, J2.11, J4.2, NT1.2, Q4.2, R8.2, R17.1, U1.1, U1.15, U1.38, U1.39, U2.4, U3.1, U3.2, U3.3, U3.4, U3.5, U3.11, U3.12, U3.20, U3.22
GNDA: C10.2, C11.2, C12.2, NT1.1, R14.2, U5.2
unnamed: D1.1, R8.1
unnamed: J1.4, R1.2
unnamed: J1.5, R2.2
unnamed: J4.1, U3.21
unnamed: L2.1, U5.3
unnamed: Q1.1, R3.2
unnamed: Q2.1, R4.2
unnamed: Q4.1, R12.2
unnamed: Q4.3, Q5.1, R15.1
unnamed: Q5.2, R10.1, R11.1, R15.2
unnamed: R13.2, R14.1, U5.5
unnamed: TP1.1, U1.4
unnamed: TP2.1, U1.6

## KiCad design boards/Jana-Marie__EF-S-Adapter__lensmount-v1.1/unrouted.kicad_pcb

Board: 2 copper layers, 65.0 x 65.0 mm, 39 parts (31 on the bottom side), 26 nets, no tracks yet.

Parts:
C1, C2, C5: 100n; C_0402
C3, C4, C6, C7: 1u; C_0603
J1: VBAT; PH-MVF-5365
J2: DETECT; PH-MVF-5365
J3: AGND; PH-MVF-5365
J4: VDD; PH-MVF-5365
J5: DOUT; PH-MVF-5365
J6: DIN; PH-MVF-5365
J7: DCLK; PH-MVF-5365
J8: DGND; PH-MVF-5365
J9: USB; USB-C 16Pin
J10: Picoblade DNP; Molex_PicoBlade_53398-0471_1x04-1MP_P1.25mm_Vertical
P1: TC2030-CTX-Tag-Connect; TC2030
Q1, Q2, Q3: 2N7002; SOT-23
Q4, Q5: AO3401A; SOT-23
R1, R2, R3, R4, R5, R6, R7, R8, R11, R13: 5k1; R_0402
R9: 0; R_0402
R10, R12: 100k; R_0402
U1: STM32F042F6Px; TSSOP-20_4.4x6.5mm_P0.65mm
U2: XC6206PxxxMR; SOT-23
U3: USBLC6-4; SOT-23-6

Connections:
+3V3: C1.1, C4.1, P1.1, Q1.1, Q2.1, Q3.1, R3.1, R4.1, R5.1, U1.5, U1.16, U2.2
+BATT: C6.1, Q4.2, R9.1, R10.1
D+: J9.A6, J9.B6, U1.18, U3.3
D-: J9.A7, J9.B7, U1.17, U3.1
DCLK_3V3: Q3.2, R5.2, U1.11
DCLK_5V: J7.1, Q3.3, R8.2
DETECT: J2.1, U1.10
DIN_3V3: Q1.2, R3.2, U1.13
DIN_5V: J6.1, Q1.3, R6.2
DOUT_3V3: Q2.2, R4.2, U1.12
DOUT_5V: J5.1, Q2.3, R7.2
EN_VBAT: R11.2, U1.2
EN_VBUS: R13.2, U1.3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, J3.1, J8.1, J9.A1, J9.A12, J9.B1, J9.B12, J9.S1, J10.1, J10.MP, P1.5, R1.1, R2.1, U1.15, U2.1, U3.2
NRST: C2.1, P1.3, U1.4
unnamed: J1.1, Q4.3
unnamed: J4.1, Q5.3
unnamed: J9.A5, R1.2
unnamed: J9.B5, R2.2
unnamed: Q4.1, R10.2, R11.1
unnamed: Q5.1, R12.2, R13.1
SWCLK: P1.4, U1.20
SWDIO: P1.2, U1.19
UART_RX: J10.3, U1.9
UART_TX: J10.4, U1.8
VBUS: C3.1, C5.1, C7.1, J9.A4, J9.A9, J9.B4, J9.B9, J10.2, Q5.2, R6.1, R7.1, R8.1, R9.2, R12.1, U2.3, U3.5

## KiCad design boards/Jana-Marie__LAEMP-Prism__laemp_wall/unrouted.kicad_pcb

Board: 2 copper layers, 40.0 x 180.0 mm, 86 parts (86 on the bottom side), 44 nets, no tracks yet.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42, C43: 100n; C_0402
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41: SK6812; LED_SK6812_PLCC4_5.0x5.0mm_P3.2mm
J1: CON; conn_01x06_smd_2mm
J2: Conn_01x02; conn_01x02_smd_2mm

Connections:
DIN: D1.2, J1.6
DOUT: D41.4, J1.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.1, C42.2, C43.1, C43.2, D1.1, D2.1, D3.1, D4.1, D5.1, D6.1, D7.1, D8.1, D9.1, D10.1, D11.1, D12.1, D13.1, D14.1, D15.1, D16.1, D17.1, D18.1, D19.1, D20.1, D21.1, D22.1, D23.1, D24.1, D25.1, D26.1, D27.1, D28.1, D29.1, D30.1, D31.1, D32.1, D33.1, D34.1, D35.1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
unnamed: D1.4, D2.2
unnamed: D2.4, D25.2
unnamed: D3.4, D4.2
unnamed: D4.4, D5.2
unnamed: D5.4, D6.2
unnamed: D6.4, D7.2
unnamed: D7.4, D8.2
unnamed: D8.4, D9.2
unnamed: D9.4, D10.2
unnamed: D10.4, D11.2
unnamed: D11.4, D12.2
unnamed: D12.4, D13.2
unnamed: D13.4, D14.2
unnamed: D14.4, D15.2
unnamed: D15.4, D16.2
unnamed: D16.4, D17.2
unnamed: D17.4, D18.2
unnamed: D18.4, D19.2
unnamed: D19.4, D20.2
unnamed: D20.4, D21.2
unnamed: D21.4, D22.2
unnamed: D22.4, D23.2
unnamed: D23.4, D24.2
unnamed: D24.4, D26.2
unnamed: D3.2, D25.4
unnamed: D26.4, D27.2
unnamed: D27.4, D28.2
unnamed: D28.4, D29.2
unnamed: D29.4, D30.2
unnamed: D30.4, D31.2
unnamed: D31.4, D32.2
unnamed: D32.4, D33.2
unnamed: D33.4, D34.2
unnamed: D34.4, D35.2
unnamed: D35.4, D36.2
unnamed: D36.4, D37.2
unnamed: D37.4, D38.2
unnamed: D38.4, D39.2
unnamed: D39.4, D40.2
unnamed: D40.4, D41.2
VBUS: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, D1.3, D2.3, D3.3, D4.3, D5.3, D6.3, D7.3, D8.3, D9.3, D10.3, D11.3, D12.3, D13.3, D14.3, D15.3, D16.3, D17.3, D18.3, D19.3, D20.3, D21.3, D22.3, D23.3, D24.3, D25.3, D26.3, D27.3, D28.3, D29.3, D30.3, D31.3, D32.3, D33.3, D34.3, D35.3, D36.3, D37.3, D38.3, D39.3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
