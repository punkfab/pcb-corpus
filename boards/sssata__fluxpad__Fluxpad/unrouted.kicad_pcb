# Repository punkfab/pcb-corpus

## KiCad design boards/sssata__fluxpad__Fluxpad/unrouted.kicad_pcb

Board: 4 copper layers, 70.0 x 68.0 mm, 76 parts (57 on the bottom side), 47 nets, no tracks yet.

Parts:
3V3: TestPoint; TestPoint_Pad_1.0x1.0mm
C1, C2, C3, C4, C10, C22, C23, C24, C25: 1uF; C_0402_1005Metric
C5: 22uf; C_0805_2012Metric
C6: 10uf; C_0603_1608Metric
C7, C8, C9, C11, C12, C13, C14, C15, C16, C19: 100n; C_0402_1005Metric
C17, C18: 1u; C_0402_1005Metric
C20, C21: 30p; C_0402_1005Metric
D1, D2, D3, D4, D5: WHITE LED; 1208 Counterpost LED
D6, D7, D8: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
GND1: TestPoint; TestPoint_Pad_1.0x1.0mm
H1, H2, H3, H4, H5: MountingHole; MountingHole_2.2mm_M2_ISO7380
H6, H7, H8: Tooling Hole; JLC Tooling Hole
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
R1, R2, R3, R4, R15: 22; R_0603_1608Metric
R5: 560; R_0603_1608Metric
R6, R14, R16: 100; R_0603_1608Metric
R7, R8: 5.1k; R_0402_1005Metric
R9, R10: 10k; R_0402_1005Metric
R11, R12: 22; R_0402_1005Metric
R13: 1k; R_0402_1005Metric
SW1, SW2: SW_SPST; SW_Hotswap_Kailh_MX_no_pads
SW3: EC12E24204A7; RotaryEncoder_Alps_EC12E_Vertical_H20mm_CircularMountingHol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
SW4: RESET; SPST SMD TS-1187A-B-A-B
SW5: BOOTSEL; SPST SMD TS-1187A-B-A-B
SW6, SW7: SW_SPST; Kailh Hot Swap Socket
U1: 74AHCT1G125; SOT-353_SC-70-5
U2, U3, U5: DRV5056A3QDBZx Lekker; SW_Cherry_MX_PCB_1.00u_hall_effect
U4: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm
U6: W25Q128JVS; SOIC-8_5.23x5.23mm_P1.27mm
U7: USBLC6-2SC6; SOT-23-6
U8: AMS1117-3.3; SOT-223-3_TabPin2
Y1: Crystal_GND24; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+1V1: C15.1, C16.1, C17.1, U4.23 (DVDD), U4.45 (VREG_VOUT), U4.50 (DVDD)
+3V3: 3V3.1, C1.1, C2.1, C5.2, C7.1, C8.1, C9.1, C11.1, C12.1, C13.1, C14.1, C18.1, C19.1, C22.1, R9.1, R10.1, U2.1 (VCC), U3.1 (VCC), U4.1 (IOVDD), U4.10 (IOVDD), U4.22 (IOVDD), U4.33 (IOVDD), U4.42 (IOVDD), U4.43 (ADC_AVDD), U4.44 (VREG_IN), U4.48 (USB_VDD), U4.49 (IOVDD), U5.1 (VCC), U6.8 (VCC), U8.2 (VO)
+5V: C3.2, C4.1, C6.1, C10.1, D6.1 (VDD), D7.1 (VDD), D8.1 (VDD), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U1.5 (VCC), U7.5 (VBUS), U8.3 (VI)
/CC1: J1.A5 (CC1), R7.1
/CC2: J1.B5 (CC2), R8.2
/ENCA: SW3.A, U4.36 (GPIO24)
/ENCB: SW3.B, U4.35 (GPIO23)
/LED1: R1.2, U4.7 (GPIO5)
/LED2: R2.2, U4.8 (GPIO6)
/LED3: R3.2, U4.5 (GPIO3)
/LED4: R4.2, U4.6 (GPIO4)
/LED5: R15.2, U4.9 (GPIO7)
/QSPI_SCLK: U4.52 (QSPI_SCLK), U6.6 (CLK)
/QSPI_SD0: U4.53 (QSPI_SD0), U6.5 (DI(IO0))
/QSPI_SD1: U4.55 (QSPI_SD1), U6.2 (DO(IO1))
/QSPI_SD2: U4.54 (QSPI_SD2), U6.3 (IO2)
/QSPI_SD3: U4.51 (QSPI_SD3), U6.7 (IO3)
/QSPI_SS: R10.2, R13.2, U4.56 (QSPI_SS), U6.1 (~CS)
/RGB_DOUT: U1.2, U4.14 (GPIO11)
/RUN: R9.2, SW4.2, U4.26 (RUN)
/SW1: SW6.1 (A), U4.31 (GPIO20)
/SW2: SW7.1 (A), U4.32 (GPIO21)
/SW3: C24.2, R6.2, U4.40 (GPIO28_ADC2)
/SW4: C23.2, R14.2, U4.39 (GPIO27_ADC1)
/SW5: C25.2, R16.2, U4.38 (GPIO26_ADC0)
/USB_DN: R12.2, U7.6 (I/O1)
/USB_DP: R11.1, U7.4 (I/O2)
/USB_IN_DN: J1.A7 (D-), J1.B7 (D-), U7.1 (I/O1)
/USB_IN_DP: J1.A6 (D+), J1.B6 (D+), U7.3 (I/O2)
/XIN: C21.2, U4.20 (XIN), Y1.1
/XOUT: C20.2, U4.21 (XOUT), Y1.3
GND: C1.2, C2.2, C3.1, C4.2, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.1, C21.1, C22.2, C23.1, C24.1, C25.1, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.3 (VSS), D7.3 (VSS), D8.3 (VSS), GND1.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), R7.2, R8.1, SW3.C, SW4.1, SW5.1, SW6.2 (B), SW7.2 (B), U1.1, U1.3 (GND), U2.3 (GND), U3.3 (GND), U4.19 (TESTEN), U4.57 (GND), U5.3 (GND), U6.4 (GND), U7.2 (GND), U8.1 (GND), Y1.2, Y1.4
unnamed: D1.2 (A), R1.1
unnamed: D2.2 (A), R2.1
unnamed: D3.2 (A), R3.1
unnamed: D4.2 (A), R4.1
unnamed: D5.2 (A), R15.1
unnamed: D6.4 (DIN), R5.2
unnamed: D6.2 (DOUT), D7.4 (DIN)
unnamed: D7.2 (DOUT), D8.4 (DIN)
unnamed: R5.1, U1.4
unnamed: R13.1, SW5.2
unnamed: R6.1, U2.2 (OUT)
unnamed: R14.1, U3.2 (OUT)
unnamed: R12.1, U4.46 (USB_DM)
unnamed: R11.2, U4.47 (USB_DP)
unnamed: R16.1, U5.2 (OUT)

## KiCad design boards/stack-chan__stack-chan__m5-pantilt/unrouted.kicad_pcb

Board: 2 copper layers, 50.0 x 50.0 mm, 38 parts (2 on the bottom side), 40 nets, no tracks yet.

Parts:
C1, C2, C3, C4: 100u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C5: 0.1u; C_0603_1608Metric
D1: SS54; D_SMA
D2: PMEG3030EP; D_SOD-128
Hole1, Hole2, Hole3, Hole4: mountinghole_M2_M3
J1: Conn_02x15_Odd_Even; PinHeader_2x15_P2.54mm_Vertical_SMD
J2: Conn_02x15_Odd_Even; PinSocket_2x15_P2.54mm_Vertical_SMD
J3, J8: Conn_01x03; JST_EH_B3B-EH-A_1x03_P2.50mm_Vertical
J5: BAT; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J6: Conn_01x04; JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal
J7: 5V_POWER; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
LOGO: LOGO; avatar_small
Q1: IRLML6402; SOT-23
Q2: BC857; SOT-23
R1: 10k; R_0603_1608Metric
R2: 5.1k; R_0603_1608Metric
R3, R4: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 47k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 2k; R_0603_1608Metric
R7: 20k; R_0603_1608Metric
R8, R15: 2.2k; R_0603_1608Metric
R9, R10, R11, R12: 0; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13, R14: 0; R_0603_1608Metric
SW1: SW_SPDT; SW_CuK_OS102011MA1QN1_SPDT_Angled
U1: MAX3485; SO-8_5.3x6.2mm_P1.27mm

Connections:
+3V3: C5.1, J1.11, J2.11, Q2.2 (E), R1.1, R6.1, R8.1, U1.8 (VCC)
+5V: D1.1 (K), D2.2 (A), J1.27, J2.27, J6.2
/BAT: J1.29, J2.29, Q1.3 (D)
/PIN1: J1.1, J2.1
/PIN5: J1.5, J2.5
/PIN7: J1.7, J2.7
/PIN8: J1.8, J2.8
/PIN10: J1.10, J2.10
/PIN12: J1.12, J2.12
/PIN13: J1.13, J2.13
/PIN14: J1.14, J2.14
/PIN17: J1.17, J2.17
/PIN18: J1.18, J2.18
/PIN23: J1.23, J2.23
/PIN24: J1.24, J2.24
/PIN25: J1.25, J2.25
/PIN26: J1.26, J2.26
/PIN28: J1.28, J2.28
/PIN30: J1.30, J2.30
/PORTB1: J1.9, J2.9, J6.3
/PORTB2: J1.3, J2.3, J6.4
/PWM1: R3.2, R9.1, R10.1
/PWM1_C1: J1.19, J2.19, R9.2
/PWM1_C2: J1.21, J2.21, R10.2
/PWM2: R4.2, R11.1, R12.1
/PWM2_C1: J1.20, J2.20, R11.2
/PWM2_C2: J1.22, J2.22, R12.2
/RXD2: J1.16, J2.16, U1.1 (RO)
/TTL: R6.2, R14.1, U1.6 (A)
/TXD2: J1.15, J2.15, R1.2, R2.1, U1.4 (DI)
GND: C1.1, C2.1, C3.2, C4.1, C5.2, J1.2, J1.4, J1.6, J2.2, J2.4, J2.6, J3.1, J5.2, J6.1, J7.2, J8.1, R7.2, R15.2, SW1.3 (C), U1.5 (GND)
unnamed: D1.2 (A), J7.1
unnamed: C1.2, C2.2, C3.1, C4.2, D2.1 (K), J3.2, J8.2
unnamed: J3.3, R3.1, R13.2
unnamed: J5.1, Q1.2 (S), R5.2
unnamed: J8.3, R4.1, R13.1, R14.2
unnamed: Q1.1 (G), R5.1, SW1.2 (B)
unnamed: Q2.1 (B), R2.2
unnamed: Q2.3 (C), R7.1, U1.2 (~RE), U1.3 (DE)
unnamed: R8.2, R15.1, U1.7 (B)

## KiCad design boards/stas2k__galspanic__galspanic/unrouted.kicad_pcb

Board: 2 copper layers, 50.0 x 149.9 mm, 19 parts (0 on the bottom side), 56 nets, no tracks yet.

Parts:
C1, C2, C3, C4, C5, C6: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7: 220uF; CP_Radial_D6.3mm_P2.50mm
J1: x68000_expansion
JP1, JP2, JP3, JP4, JP5: SolderJumper_3_Bridged12; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
U1, U2, U3, U4, U5: CY62167E; TSOP-I-48_18.4x12mm_P0.5mm
U6: ATF22V10C-10XU; TSSOP-24_4.4x7.8mm_P0.65mm

Connections:
/A1: J1.B5 (AB1), U1.25 (A0), U2.25 (A0), U3.25 (A0), U4.25 (A0), U5.25 (A0)
/A2: J1.B6 (AB2), U1.24 (A1), U2.24 (A1), U3.24 (A1), U4.24 (A1), U5.24 (A1)
/A3: J1.B7 (AB3), U1.23 (A2), U2.23 (A2), U3.23 (A2), U4.23 (A2), U5.23 (A2)
/A4: J1.B8 (AB4), U1.22 (A3), U2.22 (A3), U3.22 (A3), U4.22 (A3), U5.22 (A3)
/A5: J1.B9 (AB5), U1.21 (A4), U2.21 (A4), U3.21 (A4), U4.21 (A4), U5.21 (A4)
/A6: J1.B10 (AB6), U1.20 (A5), U2.20 (A5), U3.20 (A5), U4.20 (A5), U5.20 (A5)
/A7: J1.B12 (AB7), U1.19 (A6), U2.19 (A6), U3.19 (A6), U4.19 (A6), U5.19 (A6)
/A8: J1.B13 (AB8), U1.18 (A7), U2.18 (A7), U3.18 (A7), U4.18 (A7), U5.18 (A7)
/A9: J1.B14 (AB9), U1.8 (A8), U2.8 (A8), U3.8 (A8), U4.8 (A8), U5.8 (A8)
/A10: J1.B15 (AB10), U1.7 (A9), U2.7 (A9), U3.7 (A9), U4.7 (A9), U5.7 (A9)
/A11: J1.B16 (AB11), U1.6 (A10), U2.6 (A10), U3.6 (A10), U4.6 (A10), U5.6 (A10)
/A12: J1.B17 (AB12), U1.5 (A11), U2.5 (A11), U3.5 (A11), U4.5 (A11), U5.5 (A11)
/A13: J1.B18 (AB13), U1.4 (A12), U2.4 (A12), U3.4 (A12), U4.4 (A12), U5.4 (A12)
/A14: J1.B19 (AB14), U1.3 (A13), U2.3 (A13), U3.3 (A13), U4.3 (A13), U5.3 (A13)
/A15: J1.B20 (AB15), U1.2 (A14), U2.2 (A14), U3.2 (A14), U4.2 (A14), U5.2 (A14)
/A16: J1.B22 (AB16), U1.1 (A15), U2.1 (A15), U3.1 (A15), U4.1 (A15), U5.1 (A15)
/A17: J1.B23 (AB17), U1.48 (A16), U2.48 (A16), U3.48 (A16), U4.48 (A16), U5.48 (A16)
/A18: J1.B24 (AB18), U1.17 (A17), U2.17 (A17), U3.17 (A17), U4.17 (A17), U5.17 (A17)
/A19: J1.B25 (AB19), U1.16 (A18), U2.16 (A18), U3.16 (A18), U4.16 (A18), U5.16 (A18)
/A20: J1.B26 (AB20), U1.9 (A19), U2.9 (A19), U3.9 (A19), U4.9 (A19), U5.9 (A19), U6.11 (I10)
/A21: J1.B27 (AB21), U6.10 (I9)
/A22: J1.B28 (AB22), U6.9 (I8)
/A23: J1.B29 (AB23), U6.8 (I7)
/CEM1: U1.12 (CE2), U6.18 (IO4)
/CEM2: U2.12 (CE2), U6.17 (IO3)
/CEM3: U3.12 (CE2), U6.16 (IO2)
/CEM4: U4.12 (CE2), U6.15 (IO1)
/CEM5: U5.12 (CE2), U6.14 (IO0)
/D0: J1.A4 (DB0), U1.29 (DQ0), U2.29 (DQ0), U3.29 (DQ0), U4.29 (DQ0), U5.29 (DQ0)
/D1: J1.A5 (DB1), U1.31 (DQ1), U2.31 (DQ1), U3.31 (DQ1), U4.31 (DQ1), U5.31 (DQ1)
/D2: J1.A6 (DB2), U1.33 (DQ2), U2.33 (DQ2), U3.33 (DQ2), U4.33 (DQ2), U5.33 (DQ2)
/D3: J1.A7 (DB3), U1.35 (DQ3), U2.35 (DQ3), U3.35 (DQ3), U4.35 (DQ3), U5.35 (DQ3)
/D4: J1.A8 (DB4), U1.38 (DQ4), U2.38 (DQ4), U3.38 (DQ4), U4.38 (DQ4), U5.38 (DQ4)
/D5: J1.A9 (DB5), U1.40 (DQ5), U2.40 (DQ5), U3.40 (DQ5), U4.40 (DQ5), U5.40 (DQ5)
/D6: J1.A10 (DB6), U1.42 (DQ6), U2.42 (DQ6), U3.42 (DQ6), U4.42 (DQ6), U5.42 (DQ6)
/D7: J1.A12 (DB7), U1.44 (DQ7), U2.44 (DQ7), U3.44 (DQ7), U4.44 (DQ7), U5.44 (DQ7)
/D8: J1.A13 (DB8), U1.30 (DQ8), U2.30 (DQ8), U3.30 (DQ8), U4.30 (DQ8), U5.30 (DQ8)
/D9: J1.A14 (DB9), U1.32 (DQ9), U2.32 (DQ9), U3.32 (DQ9), U4.32 (DQ9), U5.32 (DQ9)
/D10: J1.A15 (DB10), U1.34 (DQ10), U2.34 (DQ10), U3.34 (DQ10), U4.34 (DQ10), U5.34 (DQ10)
/D11: J1.A16 (DB11), U1.36 (DQ11), U2.36 (DQ11), U3.36 (DQ11), U4.36 (DQ11), U5.36 (DQ11)
/D12: J1.A17 (DB12), U1.39 (DQ12), U2.39 (DQ12), U3.39 (DQ12), U4.39 (DQ12), U5.39 (DQ12)
/D13: J1.A18 (DB13), U1.41 (DQ13), U2.41 (DQ13), U3.41 (DQ13), U4.41 (DQ13), U5.41 (DQ13)
/D14: J1.A19 (DB14), U1.43 (DQ14), U2.43 (DQ14), U3.43 (DQ14), U4.43 (DQ14), U5.43 (DQ14)
/D15: J1.A20 (DB15), U1.45 (DQ15/A20), U2.45 (DQ15/A20), U3.45 (DQ15/A20), U4.45 (DQ15/A20), U5.45 (DQ15/A20)
/MS4: JP4.2 (C), U6.19 (IO5)
/MS6: JP3.2 (C), U6.20 (IO6)
/MS8: JP2.2 (C), U6.21 (IO7)
/MS10: JP1.2 (C), U6.22 (IO8)
/MSK: JP5.2 (C), U6.23 (IO9)
/~AS: J1.A27 (#AS), U6.7 (I6)
/~DTACK: J1.A36 (#DTACK), U6.1 (I0/CLK)
/~LDS: J1.A28 (#LDS), U1.15 (BLE#), U2.15 (BLE#), U3.15 (BLE#), U4.15 (BLE#), U5.15 (BLE#)
/~R/W: J1.A30 (R/W), U1.11 (WE#), U2.11 (WE#), U3.11 (WE#), U4.11 (WE#), U5.11 (WE#)
/~UDS: J1.A29 (#UDS), U1.14 (BHE#), U2.14 (BHE#), U3.14 (BHE#), U4.14 (BHE#), U5.14 (BHE#)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, J1.A1 (GND), J1.A3 (GND), J1.A11 (GND), J1.A21 (GND), J1.A41 (GND), J1.B1 (GND), J1.B11 (GND), J1.B21 (GND), J1.B41 (GND), JP1.3 (B), JP2.3 (B), JP3.3 (B), JP4.3 (B), JP5.3 (B), U1.26 (CE1#), U1.27 (VSS), U1.28 (OE#), U1.46 (VSS), U2.26 (CE1#), U2.27 (VSS), U2.28 (OE#), U2.46 (VSS), U3.26 (CE1#), U3.27 (VSS), U3.28 (OE#), U3.46 (VSS), U4.26 (CE1#), U4.27 (VSS), U4.28 (OE#), U4.46 (VSS), U5.26 (CE1#), U5.27 (VSS), U5.28 (OE#), U5.46 (VSS), U6.2 (I1), U6.3 (I2), U6.4 (I3/PD), U6.5 (I4), U6.6 (I5), U6.12 (GND), U6.13 (I11)
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, J1.A49 (+5V), J1.A50 (+5V), J1.B49 (+5V), J1.B50 (+5V), JP1.1 (A), JP2.1 (A), JP3.1 (A), JP4.1 (A), JP5.1 (A), U1.37 (VCC), U1.47 (BYTE#), U2.37 (VCC), U2.47 (BYTE#), U3.37 (VCC), U3.47 (BYTE#), U4.37 (VCC), U4.47 (BYTE#), U5.37 (VCC), U5.47 (BYTE#), U6.24 (VCC)

## KiCad design boards/steelpuxnastik__SHINSANWASWITCH__shinsanwaswitch_v1/unrouted.kicad_pcb

Board: 2 copper layers, 26.3 x 15.4 mm, 9 parts (0 on the bottom side), 8 nets, no tracks yet.

Parts:
C1: 0.1uf; C_Disc_D3.8mm_W2.6mm_P2.50mm
J1: Conn_01x05_Male; JST_PH_S5B-PH-K_1x05_P2.00mm_Horizontal
LED1: Conn_01x02_Female; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
PC1: RPI-352
Q1: 2SC5395; TO-92S_Wide
R1: 330; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R2: 22K; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R3: 10K; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
STI1: NSI45020AT1G; D_SOD-123

Connections:
/+5V: C1.2, J1.3, R1.1, R2.1
/+12V: J1.1, STI1.2
/GNDA: J1.2, LED1.1
/OUT: J1.4, Q1.2 (C)
GND: C1.1, J1.5, PC1.1, PC1.4, Q1.1 (E), R3.2
unnamed: LED1.2, STI1.1
unnamed: PC1.2, R1.2
unnamed: PC1.3, Q1.3 (B), R2.2, R3.1

## KiCad design boards/sufst__pcb__16Ch-Sensor-Hub/unrouted.kicad_pcb

Board: 4 copper layers, 83.4 x 46.3 mm, 170 parts (16 on the bottom side), 85 nets, no tracks yet.

Parts:
C1, C2: 4.7p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C4, C27, C28, C29, C30: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5: 4.7n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6, C9: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7, C10: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8: 10u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26: 10nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C31: 4.7u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C60, C100: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: NUP2105L; SOT-23
D2: BZT52B10; D_SOD-123
D3, D20: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19: BAT54S; SOT-23
F1, F2: 100mA; Fuse_0603_1608Metric_Pad1.05x0.95mm_HandSolder
F3: 500mA; Fuse_0603_1608Metric_Pad1.05x0.95mm_HandSolder
FB1: BLM18PG121SN1; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
J1: Conn_ARM_JTAG_SWD_10; SHF10501LDSMLC
J2: Conn_01x04_Pin; Molex_Micro-Fit_3.0_43045-0412_2x02_P3.00mm_Vertical
J3: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J4: Bottom_Left; Molex_Micro-Fit_3.0_43045-1200_2x06_P3.00mm_Horizontal
J5: Top_Left; Molex_Micro-Fit_3.0_43045-1200_2x06_P3.00mm_Horizontal
J6: Top_Right; Molex_Micro-Fit_3.0_43045-1200_2x06_P3.00mm_Horizontal
J7: Bottom_Right; Molex_Micro-Fit_3.0_43045-1200_2x06_P3.00mm_Horizontal
JP1, JP3: SolderJumper_3_Bridged12; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
JP2: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
JP4, JP5, JP6, JP7, JP8, JP9, JP10, JP11, JP12, JP13, JP14, JP15, JP16, JP17, JP18, JP19: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
Q2: DMP510DL-7; SOT-23
R1, R3, R6: 100; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R7, R11, R14, R17, R20, R23, R26, R29, R32, R35, R38, R41, R44, R47, R50, R53, R56: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R5: 60R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8: 1.5k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9, R12, R15, R18, R21, R24, R27, R30, R33, R36, R39, R42, R45, R48, R51, R54: 40k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10, R13, R16, R19, R22, R25, R28, R31, R34, R37, R40, R43, R46, R49, R52, R55: NC; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R57, R58: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R59: 220; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: RESET; SW_Push_1P1T_NO_CK_KMR2
U1: TCAN3404-Q1; SOT-23-8_Handsoldering
U2: STM32F105RBTx; LQFP-64_10x10mm_P0.5mm
U3: AP7375Q-33SF; Diodes_SO-8EP
U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16, U17, U18, U19: TLV9101IDBVR; SOT-23-5_HandSoldering
U20: ISM330DHCX; LGA-14_3x2.5mm_P0.5mm_LayoutBorder3x4y
U21: MCP9800Ax-xOT; SOT-23-5
Y1: ECS-250-10-47Q-CES-TR; Resonator_SMD_ECS_ECX-1247Q_1.6x1.2x0.3mm

Connections:
+3V3: C4.2, C10.1, C27.1, C28.1, C29.1, C30.1, C31.1, C60.1, C100.2, D4.2 (K), D5.2 (K), D6.2 (K), D7.2 (K), D8.2 (K), D9.2 (K), D10.2 (K), D11.2 (K), D12.2 (K), D13.2 (K), D14.2 (K), D15.2 (K), D16.2 (K), D17.2 (K), D18.2 (K), D19.2 (K), F1.1, F2.1, FB1.1, J1.1 (VTref), JP1.3 (B), JP3.3 (B), R2.2, R10.2, R13.2, R16.2, R19.2, R22.2, R25.2, R28.2, R31.2, R34.2, R37.2, R40.2, R43.2, R46.2, R49.2, R52.2, R55.2, R57.2, R58.2, U1.3 (VCC), U2.1 (VBAT), U2.19 (VDD), U2.32 (VDD), U2.48 (VDD), U2.64 (VDD), U3.1 (VOUT), U20.1 (SDO/SA0), U20.5 (VDDIO), U20.8 (VDD), U20.12 (CS), U21.1 (V_{DD})
+3V3A: C6.1, C7.1, FB1.2, U2.13 (VDDA)
+GLV: F3.2, Q2.3 (D)
+GLV_PROT: C9.1, D2.1 (K-), D3.2 (A), Q2.2 (S), U3.7 (EN), U3.8 (VIN), U4.5 (V+), U5.5 (V+), U6.5 (V+), U7.5 (V+), U8.5 (V+), U9.5 (V+), U10.5 (V+), U11.5 (V+), U12.5 (V+), U13.5 (V+), U14.5 (V+), U15.5 (V+), U16.5 (V+), U17.5 (V+), U18.5 (V+), U19.5 (V+)
/3V3_FUSED_L: F2.2, J4.3, J4.6, J4.9, J4.12, J5.3, J5.6, J5.9, J5.12
/3V3_FUSED_R: F1.2, J6.3, J6.6, J6.9, J6.12, J7.3, J7.6, J7.9, J7.12
/ADC_L_1: C15.1, D8.3 (COM), R21.1, R22.1, R23.2, U2.26 (PB0)
/ADC_L_2: C16.1, D9.3 (COM), R24.1, R25.1, R26.2, U2.24 (PC4)
/ADC_L_3: C11.1, D4.3 (COM), R9.1, R10.1, R11.2, U2.27 (PB1)
/ADC_L_4: C12.1, D5.3 (COM), R12.1, R13.1, R14.2, U2.25 (PC5)
/ADC_L_5: C17.1, D10.3 (COM), R27.1, R28.1, R29.2, U2.22 (PA6)
/ADC_L_6: C18.1, D11.3 (COM), R30.1, R31.1, R32.2, U2.21 (PA5)
/ADC_L_7: C13.1, D6.3 (COM), R15.1, R16.1, R17.2, U2.23 (PA7)
/ADC_L_8: C14.1, D7.3 (COM), R18.1, R19.1, R20.2, U2.20 (PA4)
/ADC_R_1: C23.1, D16.3 (COM), R45.1, R46.1, R47.2, U2.10 (PC2)
/ADC_R_2: C24.1, D17.3 (COM), R48.1, R49.1, R50.2, U2.8 (PC0)
/ADC_R_3: C19.1, D12.3 (COM), R33.1, R34.1, R35.2, U2.11 (PC3)
/ADC_R_4: C20.1, D13.3 (COM), R36.1, R37.1, R38.2, U2.9 (PC1)
/ADC_R_5: C25.1, D18.3 (COM), R51.1, R52.1, R53.2, U2.14 (PA0)
/ADC_R_6: C26.1, D19.3 (COM), R54.1, R55.1, R56.2, U2.16 (PA2)
/ADC_R_7: C21.1, D14.3 (COM), R39.1, R40.1, R41.2, U2.15 (PA1)
/ADC_R_8: C22.1, D15.3 (COM), R42.1, R43.1, R44.2, U2.17 (PA3)
/CAN+: D1.2 (K), J2.3, R4.2, U1.7 (CANH)
/CAN-: D1.1 (K), J2.4, R5.1, U1.6 (CANL)
/CAN_RX: U1.4 (RXD), U2.44 (PA11)
/CAN_TX: U1.1 (TXD), U2.45 (PA12)
/ClampedDivider1/IN: J4.1, JP8.1 (A), U8.3 (+)
/ClampedDivider2/IN: J4.4, JP9.1 (A), U9.3 (+)
/ClampedDivider3/IN: J5.1, JP10.1 (A), U10.3 (+)
/ClampedDivider4/IN: J5.4, JP11.1 (A), U11.3 (+)
/ClampedDivider5/IN: J4.7, JP5.1 (A), U4.3 (+)
/ClampedDivider6/IN: J4.10, JP4.1 (A), U5.3 (+)
/ClampedDivider7/IN: J5.7, JP6.1 (A), U6.3 (+)
/ClampedDivider8/IN: J5.10, JP7.1 (A), U7.3 (+)
/ClampedDivider9/IN: J6.1, JP16.1 (A), U16.3 (+)
/ClampedDivider10/IN: J6.4, JP17.1 (A), U17.3 (+)
/ClampedDivider11/IN: J7.1, JP18.1 (A), U18.3 (+)
/ClampedDivider12/IN: J7.4, JP19.1 (A), U19.3 (+)
/ClampedDivider13/IN: J6.7, JP12.1 (A), U12.3 (+)
/ClampedDivider14/IN: J6.10, JP13.1 (A), U13.3 (+)
/ClampedDivider15/IN: J7.7, JP14.1 (A), U14.3 (+)
/ClampedDivider16/IN: J7.10, JP15.1 (A), U15.3 (+)
/I2C0_SCL: R58.1, U2.58 (PB6), U20.13 (SCL), U21.4 (SCLK)
/I2C0_SDA: R57.1, U2.59 (PB7), U20.14 (SDA), U21.5 (SDA)
/IMU_INTR1: U2.50 (PA15), U20.4 (INT1)
/IMU_INTR2: U2.54 (PD2), U20.9 (INT2)
/NReset: C3.1, J1.10 (~RESET), R2.1, SW1.2 (B), U2.7 (NRST)
/TOO_HOT: U2.53 (PC12), U21.3 (ALERT)
GND: C1.2, C2.2, C3.2, C4.1, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C60.2, C100.1, D1.3 (A), D4.1 (A), D5.1 (A), D6.1 (A), D7.1 (A), D8.1 (A), D9.1 (A), D10.1 (A), D11.1 (A), D12.1 (A), D13.1 (A), D14.1 (A), D15.1 (A), D16.1 (A), D17.1 (A), D18.1 (A), D19.1 (A), H1.1, H2.1, H3.1, H4.1, J1.3 (GND), J1.5 (GND), J1.9 (GNDDetect), J2.1, J4.2, J4.5, J4.8, J4.11, J5.2, J5.5, J5.8, J5.11, J6.2, J6.5, J6.8, J6.11, J7.2, J7.5, J7.8, J7.11, JP1.1 (A), JP3.1 (A), R7.2, R8.1, R11.1, R14.1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
unnamed: C2.1, R1.2, Y1.3
unnamed: D2.2 (A+), Q2.1 (G), R7.1
unnamed: D3.1 (K), R8.2
unnamed: D20.2 (A), U2.4 (PC15)
unnamed: D20.1 (K), R59.2
unnamed: C8.1, F3.1, J2.2
unnamed: JP1.2 (C), R3.1
unnamed: JP2.1 (A), R5.2
unnamed: JP2.3 (B), R4.1
unnamed: C5.1, JP2.2 (C)
unnamed: JP3.2 (C), R6.2
unnamed: JP4.2 (B), R12.2, U5.1, U5.4 (-)
unnamed: JP5.2 (B), R9.2, U4.1, U4.4 (-)
unnamed: JP6.2 (B), R15.2, U6.1, U6.4 (-)
unnamed: JP7.2 (B), R18.2, U7.1, U7.4 (-)
unnamed: JP8.2 (B), R21.2, U8.1, U8.4 (-)
unnamed: JP9.2 (B), R24.2, U9.1, U9.4 (-)
unnamed: JP10.2 (B), R27.2, U10.1, U10.4 (-)
unnamed: JP11.2 (B), R30.2, U11.1, U11.4 (-)
unnamed: JP12.2 (B), R33.2, U12.1, U12.4 (-)
unnamed: JP13.2 (B), R36.2, U13.1, U13.4 (-)
unnamed: JP14.2 (B), R39.2, U14.1, U14.4 (-)
unnamed: JP15.2 (B), R42.2, U15.1, U15.4 (-)
unnamed: JP16.2 (B), R45.2, U16.1, U16.4 (-)
unnamed: JP17.2 (B), R48.2, U17.1, U17.4 (-)
unnamed: JP18.2 (B), R51.2, U18.1, U18.4 (-)
unnamed: JP19.2 (B), R54.2, U19.1, U19.4 (-)
unnamed: R3.2, U2.60 (BOOT0)
unnamed: R6.1, U2.28 (PB2)
unnamed: C1.1, U2.5 (PD0), Y1.1
unnamed: R1.1, U2.6 (PD1)
SYS_JTCK-SW: J1.4 (SWCLK/TCK), U2.49 (PA14)
SYS_JTDO: J1.6 (SWO/TDO), U2.55 (PB3)
SYS_JTMS-SWDIO: J1.2 (SWDIO/TMS), U2.46 (PA13)
USART1_RX: J3.2, U2.43 (PA10)
USART1_TX: J3.1, U2.42 (PA9)

## KiCad design boards/tcsullivan__noisecard__noisecard/unrouted.kicad_pcb

Board: 2 copper layers, 85.0 x 50.0 mm, 32 parts (0 on the bottom side), 26 nets, no tracks yet.

Parts:
B1: KXOB25-02X8F-TR; KXOB25-02X8F-TR_IXY
C1: 4u7; C_0805_2012Metric
C2: 10u; C_0805_2012Metric
C3, C4: 330u; CP_EIA-7343-15_Kemet-W
C5, C6, C9: 0.1U; C_0603_1608Metric
C7: 200P; C_0603_1608Metric
C8: 2U2; C_0805_2012Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10: LED; LED_0603_1608Metric
H1: MountingHole_Pad; MountingHole_2.5mm
J1: Conn_ARM_SWD_TagConnect_TC2030-NL; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
L1: 10u; L_0805_2012Metric
MK1: SPH0645LM4H-B; MIC_SPH0645LM4H-B
R1, R2, R3, R10: 51; R_0603_1608Metric
SW1: SW_DPDT_x2; SW_DPDT_CK_JS202011JCQN
TP1: TestPoint; TestPoint_Pad_D1.0mm
U1: STM32G031F6Px; TSSOP-20_4.4x6.5mm_P0.65mm
U2: LM3670MF; TSOT-23-5

Connections:
+1V8: C2.1, C6.1, C7.1, C8.1, C9.1, J1.1 (VCC), L1.2, MK1.5 (VDD), R1.1, U1.4 (VDD), U2.4 (FB)
EN: SW1.2 (B), SW1.5 (B), U2.3 (EN)
GND: B1.1, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, J1.5 (GND), MK1.2 (SELECT), MK1.3 (GND), SW1.3 (C), SW1.6 (C), U1.5 (VSS), U2.2 (GND)
LED0: D1.1 (K), U1.1 (PB7/PB8)
LED1: D2.1 (K), U1.2 (PC14/PB9)
LED2: D3.1 (K), U1.3 (PC15)
LED3: D4.1 (K), U1.7 (PA0)
LED4: D5.1 (K), U1.8 (PA1)
LED5: D6.1 (K), U1.9 (PA2)
LED6: D7.1 (K), U1.10 (PA3)
LED7: D8.1 (K), U1.13 (PA6)
LED8: D9.1 (K), U1.15 (PB0/PB1/PB2/PA8)
LED9: D10.1 (K), U1.20 (PB3/PB4/PB5/PB6)
MIC_BCLK: MK1.4 (BCLK), R3.1
MIC_DATA_OUT: R10.2, U1.14 (PA7)
MIC_WS: MK1.1 (WS), R2.1
NRST: C5.1, U1.6 (PF2)
unnamed: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), R1.2
unnamed: MK1.6 (DATA_OUT), R10.1
unnamed: R2.2, U1.11 (PA4)
unnamed: R3.2, U1.12 (PA5)
unnamed: TP1.1, U1.17 (PA12/PA10)
unnamed: L1.1, U2.5 (SW)
SWCLK: J1.4 (SWCLK), U1.19 (PA14/PA15)
SWDIO: J1.2 (SWDIO), U1.18 (PA13)
VDC: B1.2, C1.1, C3.1, C4.1, SW1.1 (A), SW1.4 (A), U2.1 (Vin)

Notices in the files:
boards/tcsullivan__noisecard__noisecard/unrouted.kicad_pcb:
Released under the CERN Open Hardware License Version 2 - Strongly Reciprocal
boards/techy-robot__Mighty-Micro-Motors__esp32-s3_single_motor_battery_controller/unrouted.kicad_pcb:
© 2024 Asher Edwards
parts and their libraries:
License: Apache-2.0
