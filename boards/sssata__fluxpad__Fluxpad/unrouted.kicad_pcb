# Repository punkfab/pcb-corpus (continued)

## KiCad design boards/techy-robot__Mighty-Micro-Motors__esp32-s3_single_motor_battery_controller/unrouted.kicad_pcb

Board: 4 copper layers, 44.9 x 42.0 mm, 133 parts (54 on the bottom side), 89 nets, no tracks yet.

Parts:
C1, C2, C21, C24: 1uF; C_0603_1608Metric
C3, C4: 16pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5: 47nF; C_0603_1608Metric
C6, C14, C31, C35: 2.2uf; C_0603_1608Metric
C7: 1nF; C_0603_1608Metric
C8: 47nf; C_0603_1608Metric
C9, C10, C11, C15, C16, C17, C19, C20, C22, C23, C25, C33, C38: 0.1uF; C_0603_1608Metric
C12: 1uf; C_0603_1608Metric
C13: 10uF, 16v; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C18: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C26: 22uF; C_0603_1608Metric
C27, C28: 22uf; C_0603_1608Metric
C29, C30, C36: 10uF; C_0603_1608Metric
C34: 22nF; C_0603_1608Metric
C37, C39: 220nF; C_0603_1608Metric
C40: 100nF; C_0603_1608Metric
C41: 220uF,APA0609221M016R; CP_Elec_6.3x9.9
D2, D4, D5: GSDH3005; D_0402_1005Metric
D3: Osram LT Q99G.01 green led; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
FB1: 120ohm imp @100mhz; L_0603_1608Metric
H1, H2, H3, H4: Pad; TestPoint_Pad_3.0x3.0mm
H5: GND; TestPoint_Pad_D2.0mm
H6: Power; TestPoint_Pad_D2.0mm
J1: JST SH SM04B/Qwiic; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
J2: 7 pin FPC 0.3mm Panasonic Y3b; fpc_7pin_0.3mm_connector Panasonic
J3, J4: Conn_01x03; PinHeader_1x03_P1.27mm_Vertical
J5: JST XH-S; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
L1: GND joiner; SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm
L2: 5.6uH Bourns SDE0604A; L_Bourns_SDR0604
L3: 4.7uH, MAMK2520T4R7M; L_1008_2520Metric
Q1, Q2, Q4, Q5: PJA3430; SOT-323_SC-70
Q3, Q7: Vishay sir404dp; PQFN-8-EP_6x5mm_P1.27mm_Generic
R1, R23, R24, R33, R34, R35: 10ohm; R_0603_1608Metric
R2, R7: 4.02k; R_0603_1608Metric
R3, R4, R5, R6: 33ohm; R_0603_1608Metric
R8, R10, R14, R15, R16, R18, R20, R26, R31: 10k; R_0603_1608Metric
R9: 5mOhm CS wshp2818; R_2816_7142Metric
R11, R28: 2ohm; R_0603_1608Metric
R12: 866k; R_0603_1608Metric
R13: 133k; R_0603_1608Metric
R19: 80.6 ohm; R_0603_1608Metric
R21: 100k; R_0603_1608Metric
R22: 5mOhm, CS wshp2818; R_2816_7142Metric
R25: 4.02kohm; R_0603_1608Metric
R27: 1mOhm, CS wshp2818; R_2816_7142Metric
R29, R30: 100ohm; R_0603_1608Metric
R36: 5.1k; R_0603_1608Metric
SW1, SW2: KMR2; SW_Push_1P1T_NO_CK_KMR2
TP1, TP14, TP15: TestPoint; TestPoint_Pad_D1.0mm
TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP18, TP19, TP20, TP21, TP22, TP24, TP25, TP26, TP27, TP28, TP29, TP30: TestPoint_Pad_D1.0mm
U2: AP63203WU; TSOT-23-6
U3: BQ76905RGRR; VQFN20_RGR_TEX
U4: BQ24780SRUYR; RUY0028A
U5: ESP32-S3; QFN-56-1EP_7x7mm_P0.4mm_EP4x4mm
U6: 74HC595; DHVQFN-16-1EP_2.5x3.5mm_P0.5mm_EP1x2mm
Y1: 40mhz, 10ppm; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
/1A: J3.1, TP7.1, U5.21 (XTAL_32K_P), U5.41 (GPIO36)
/1B: J3.2, TP8.1, U5.22 (XTAL_32K_N), U5.42 (GPIO37)
/1C: J3.3, TP9.1, U5.36 (SPICLK_N), U5.43 (GPIO38)
/1CSA-A: J4.1, TP10.1, U5.6 (GPIO1)
/1CSA-B: J4.2, TP11.1, U5.7 (GPIO2)
/1CSA-C: J4.3, TP12.1, U5.9 (GPIO4)
/CS0: TP1.1, U5.48 (MTMS)
/CS1: J2.5, R6.1, R16.2
/LED: R19.1, U5.51 (GPIO45)
/MISO1: J2.4, R3.2
/MOSI1: J2.6, R4.2
/MOTORPWR: C10.2, C11.1, C28.1, C29.2, C30.2, C41.1, H6.1, Q1.1 (D), Q3.1 (D), Q3.2 (D), Q3.3 (D), R9.1, U2.2 (EN), U2.3 (IN), U4.1 (ACN)
/NRST: C18.1, R20.1, SW1.2, U5.4 (CHIP_PU)
/PSU/BATT+: C16.2, C17.1, C36.2, D4.2 (A), D5.2 (A), H1.1, J5.3, R22.1, R23.1, R33.2
/PSU/BATT-: C33.1, H2.1, R27.2, R29.2
/PSU/IN: C7.1, C13.1, D2.2 (A), H3.1, Q5.1 (D), R11.2, R12.2, R28.1
/PSU/Low: C39.1, R35.1, U3.5 (VC0)
/PSU/REGN: C14.1, R8.1, R18.1, R26.2, U4.24 (REGN)
/PSU/Up: C34.1, R33.1, U3.18 (V5)
/PSU/mid: C34.2, C37.1, R34.1, U3.1 (VC3A), U3.2 (VC3B), U3.3 (VC2), U3.4 (VC1), U3.19 (VC4A), U3.20 (VC4B)
/SCK1: J2.2, R5.2
/SCL1: J1.4, R15.2, U3.12 (SCL), U4.12 (SCL), U5.16 (GPIO11)
/SDA1: J1.3, R14.2, U3.13 (SDA), U4.11 (SDA), U5.15 (GPIO10)
/UART0_RX: TP14.1, U5.50 (U0RXD)
/UART0_TX: TP15.1, U5.49 (U0TXD)
GND: C1.2, C2.2, C3.2, C4.2, C18.2, C19.2, C20.1, C21.1, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, D3.1 (K), J1.1, J1.MP (MountPin), J2.3, J2.7, L1.1, R21.2, SW1.1, SW2.1, U5.57 (GND), U6.8 (GND), U6.17 (GND), Y1.2, Y1.4
GNDPWR: C6.2, C9.1, C11.2, C12.2, C13.2, C14.2, C15.1, C17.2, C28.2, C29.1, C30.1, C31.2, C35.2, C36.1, C38.2, C41.2, H4.1, H5.1, L1.2, Q2.3 (S), Q7.1 (D), Q7.2 (D), Q7.3 (D), R13.1, U2.4 (GND), U3.8 (TS), U3.11 (VSS), U3.21 (GND), U4.13 (CMPIN), U4.22 (GND), U4.29 (PAD)
unnamed: C6.1, R11.1
unnamed: C19.1, FB1.1, U5.2 (VDD3P3), U5.3 (VDD3P3)
unnamed: C31.1, R28.2
unnamed: D2.1 (K), D4.1 (K), R10.2
unnamed: D3.2 (A), R19.2
unnamed: D5.1 (K), R31.1
unnamed: C37.2, C39.2, J5.1, R35.2
unnamed: J5.2, R34.2
unnamed: Q1.2 (G), U4.26 (HIDRV)
unnamed: C5.2, L2.1, Q1.3 (S), Q2.1 (D), U4.27 (PHASE)
unnamed: Q2.2 (G), U4.23 (LODRV)
unnamed: Q3.4 (G), R25.1
unnamed: C15.2, C16.1, L2.2, Q3.5 (S), R1.1, R22.2, R24.1
unnamed: C9.2, C10.1, Q4.1 (D), R9.2, U4.2 (ACP)
unnamed: C7.2, C8.2, Q4.2 (G), Q5.2 (G), R2.2
unnamed: C8.1, Q4.3 (S), Q5.3 (S), R7.2
unnamed: Q7.4 (G), R36.2
unnamed: C33.2, C38.1, Q7.5 (S), R27.1, R30.2
unnamed: C40.1, U2.6 (BST)
unnamed: C40.2, L3.1, U2.5 (SW)
unnamed: C35.1, R31.2, U3.16 (REGSRC), U3.17 (BAT)
unnamed: R36.1, U3.9 (DSG)
unnamed: R30.1, U3.7 (SRN)
unnamed: R29.1, U3.6 (SRP)
unnamed: R12.1, R13.2, U4.6 (ACDET)
unnamed: R2.1, U4.4 (ACDRV)
unnamed: R8.2, U4.5 (ACOK)
unnamed: R25.2, U4.18 (BATDRV)
unnamed: TP6.1, U4.15 (BATPRES_N)
unnamed: R24.2, U4.17 (BATSRC)
unnamed: C5.1, U4.25 (BTST)
unnamed: R7.1, U4.3 (CMSRC)
unnamed: R26.1, U4.21 (ILIM)
unnamed: R23.2, U4.19 (SRN)
unnamed: R1.2, U4.20 (SRP)
unnamed: R18.2, U4.16 (TB_STAT_N)
unnamed: C12.1, R10.1, U4.28 (VCC)
unnamed: SW2.2, U5.5 (GPIO0)
unnamed: R21.1, U5.8 (GPIO3)
unnamed: TP18.1, U5.14 (GPIO9)
unnamed: TP5.1, U5.24 (GPIO18)
unnamed: TP19.1, U5.25 (GPIO19/USB_D-), U6.11 (SRCLK), U6.12 (RCLK)
unnamed: TP20.1, U5.26 (GPIO20/USB_D+), U6.14 (SER)
unnamed: TP21.1, U5.27 (GPIO21), U6.13 (~OE)
unnamed: TP2.1, U5.38 (GPIO33)
unnamed: TP3.1, U5.39 (GPIO34)
unnamed: TP4.1, U5.40 (GPIO35)
unnamed: TP22.1, U5.52 (GPIO46)
unnamed: R5.1, U5.44 (MTCK)
unnamed: R3.1, U5.47 (MTDI)
unnamed: R4.1, U5.45 (MTDO)
unnamed: C4.1, U5.53 (XTAL_N), Y1.1
unnamed: C3.1, U5.54 (XTAL_P), Y1.3
unnamed: R6.2, U6.15 (QA)
unnamed: TP24.1, U6.1 (QB)
unnamed: TP25.1, U6.2 (QC)
unnamed: TP26.1, U6.3 (QD)
unnamed: TP27.1, U6.4 (QE)
unnamed: TP28.1, U6.5 (QF)
unnamed: TP29.1, U6.6 (QG)
unnamed: TP30.1, U6.7 (QH)
VDD: C1.1, C2.1, C20.2, C21.2, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, FB1.2, J1.2, J2.1, L3.2, R14.1, R15.1, R16.1, R20.2, U2.1 (FB), U5.20 (VDD3P3_RTC), U5.29 (VDD_SPI), U5.46 (VDD3P3_CPU), U5.55 (VDDA), U5.56 (VDDA), U6.16 (VCC)
