# Repository punkfab/pcb-corpus

## KiCad design boards/flypie__Ace-2019__acez180/unrouted.kicad_pcb

Board: 2 copper layers, 160.0 x 161.3 mm, 143 parts (0 on the bottom side), 248 nets, no tracks yet.

Parts:
AUDIO-IN1: 332-02; PinHeader_1x02_P2.54mm_Vertical
AUDIO-OUT1: 332-02; PinHeader_1x02_P2.54mm_Vertical
C1: 30p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C2: 100p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C3, C6: 47nF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C4, C10: 100uf; CP_Radial_D5.0mm_P2.00mm
C5: 47pF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C7: 1U; CP_Radial_D4.0mm_P1.50mm
C8, C11, C12, C13, C14, C15, C16, C17, C18, C19: 100nf; C_Disc_D3.0mm_W1.6mm_P2.50mm
C9: 100uf; CP_Radial_D4.0mm_P1.50mm
C100, C101: 22p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C404: 1u; C_Disc_D3.0mm_W1.6mm_P2.50mm
CF1, CF2, CF3, CF4: 5788643-1; 57886431
COMPOSITE-OUT1: COMPOSITE-OUT1; PinHeader_1x02_P2.54mm_Vertical
D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D601, D602, D603, D604, D605, D606: 1N4148; D_DO-35_SOD27_P2.54mm_Vertical_AnodeUp
D100: BAT54W; SOT-323_SC-70
HBL1: MountingHole; MountingHole_2.5mm
HBR1: MountingHole; MountingHole_2.5mm
HTL1: MountingHole; MountingHole_2.5mm
HTR1: MountingHole; MountingHole_2.5mm
IC1: LM7805_TO220; TO-220-3_Vertical
J300, J402: Conn_02x06_Odd_Even; PinHeader_2x06_P2.54mm_Vertical
J301, J304, J501: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical
J303, J502: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
J400: 48409-0003
KEYBOARD1: Conn_02x08_Odd_Even; PinHeader_2x08_P2.54mm_Vertical
L1: 100 nH; KEMET_SBT_0260T
LED600, LED601, LED602, LED604: WP3A8HD; LED_D3.0mm
Logo1: ZilogBack; ZilogInsideBack
Logo2: ZilogFront; ZilogInsideFront
POWER-9V-DC1: Conn_01x02; 163179PHEX
Q1, Q100: 2N3904; TO-92_Inline
Q3: BC183; TO-92L_Inline
R1: 4k7; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R2: 47k; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R5: 1K; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R6: 12k; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R9: 22k; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R10: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R11, R16: 1K5; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R17: 100; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R25: 220k; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R32: 1K0; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R100, R101, R103, R104, R105, R106, R107, R108: 270; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R102: 200; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R601, R602, R603, R604, R605, R606, R607, R608, R611, R612, R613, R614, R615, R616, R617, R618: 1K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R609, R610, R619, R620: 500; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R621: 10; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
RV1: 100; 3362H1103LF
SPK1: SPk1; PinHeader_1x02_P2.54mm_Vertical
X1: CRYSTALHC49U-V 6.556MHz; Crystal_HC49-U_Vertical
X2: 20MHz; Crystal_HC49-U_Vertical
Z0: Z80-182-L182-VQFP-100; VQFP-100_14x14mm_P0.5mm
Z1-2: SST39SF010-LCC; PLCC-32_THT-Socket
Z3-4: CY62158; TSOP-II-44_10.16x18.41mm_P0.8mm
Z5-6: IDT71321-421-52PIN-PLCC; PLCC-52
Z7-8: IDT71321; PLCC-52
Z14: SN74LS367AN; DIP-16_W7.62mm_Socket
Z19: 74AHCT00; DIP-14_W7.62mm_Socket
Z20: 74AHCT08; DIP-14_W7.62mm_Socket
Z21, Z22: 74AHCT11; DIP-14_W7.62mm_Socket
Z23: 74AHCT86; DIP-14_W7.62mm_Socket
Z24: SN74AHCT02N; DIP-14_W7.62mm_Socket
Z25: 74AHCT02; DIP-14_W7.62mm_Socket
Z27: SN74AHCT74N; DIP-14_W7.62mm_Socket
Z28: 74AHCT166; DIP-16_W7.62mm_Socket
Z29: SN74AHCT138N; DIP-16_W7.62mm_Socket
Z80CPUOUT1: Conn_02x22_Odd_Even; PinHeader_2x22_P2.54mm_Vertical
Z302: 74AHCT32; DIP-14_W7.62mm_Socket
Z303, Z304: CD74HCT4040E; DIP-16_W7.62mm_Socket
Z306, Z308: SN74AHCT04N; DIP-14_W7.62mm_Socket
Z307, Z600: SN74AHCT139N; DIP-16_W7.62mm_Socket
Z404: 74LS21; DIP-14_W7.62mm_Socket
Z407: 74AHCT30D; DIP-14_W7.62mm_Socket
Z408: STM8S003F3P; TSSOP-20_4.4x6.5mm_P0.65mm

Connections:
50Hz: Z21.6, Z25.6, Z306.9
+5V: C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, CF1.13 (Vcc), CF1.38 (Vcc), CF2.13 (Vcc), CF2.38 (Vcc), CF3.13 (Vcc), CF3.38 (Vcc), CF4.13 (Vcc), CF4.38 (Vcc), D2.1 (K), IC1.3 (VO), J300.9, J301.9, J303.5, J304.9, J400.1, J400.10, J402.11, J501.9, J502.5, Q100.3 (C), R1.1, R16.2, R25.1, R100.1, R101.1, R103.1, R104.1, R105.1, R106.1, R107.1, R108.1, R601.1, R602.1, R603.1, R604.1, R605.1, R606.1, R607.1, R608.1, R609.1, R610.1, R611.1, R612.1, R613.1, R614.1, R615.1, R616.1, R617.1, R618.1, R619.1, R620.1, SPK1.2, Z0.15 (VSS_1), Z0.46 (VDD_2), Z0.70 (VDD_3), Z1-2.32 (VCC), Z3-4.11 (VCC1), Z3-4.33 (VCC2), Z3-4.40 (CE2), Z5-6.51 (~CER), Z5-6.52 (VCC), Z7-8.51 (~CER), Z7-8.52 (VCC), Z14.16 (VCC), Z19.14 (VCC), Z20.14 (VCC), Z21.14 (VCC), Z22.14 (VCC), Z23.14 (VCC), Z24.14 (VCC)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
+9V: C4.1, C8.1, L1.1, POWER-9V-DC1.A
+9Vsm: C9.1, IC1.1 (VI), L1.2, Z80CPUOUT1.39
/ADDRDECODE/~3C00-3FFF: Z302.6, Z407.11, Z407.12
/ADDRDECODE/~CPUFONT: Z302.9, Z302.12, Z307.5 (O1)
/VDG/INVERTCHAR: Z5-6.34 (I/O7R), Z20.13
/VDG/SH~LD: Z5-6.46 (~OER), Z5-6.50 (R~WR), Z7-8.46 (~OER), Z7-8.50 (R~WR), Z19.6, Z28.15 (PE)
/VDG/VIDEN: Z19.4, Z20.9, Z22.6
/VDG/VIDEO: D11.2 (A), Q100.2 (B), R11.1, R16.1
/~BUSAK: Z0.94 (~BUSACK), Z80CPUOUT1.28
/~BUSRQ: Z0.95 (~BUSREQ), Z80CPUOUT1.24
/~HALT: Z0.81 (~HALT), Z80CPUOUT1.38
/~WAIT: Z0.93 (~WAIT), Z80CPUOUT1.26
/~WE: R32.2, Z80CPUOUT1.1
A0: Z0.2 (A0), Z1-2.12 (A0), Z3-4.5 (A0), Z5-6.7 (A0L), Z7-8.7 (A0L), Z80CPUOUT1.7, Z307.14 (A0)
A1: Z0.3 (A1), Z1-2.11 (A1), Z3-4.4 (A1), Z5-6.8 (A1L), Z7-8.8 (A1L), Z80CPUOUT1.8, Z307.13 (A1)
A2: Z0.4 (A2), Z1-2.10 (A2), Z3-4.3 (A2), Z5-6.9 (A2L), Z7-8.9 (A2L), Z80CPUOUT1.17, Z308.3
A3: Z0.5 (A3), Z1-2.9 (A3), Z3-4.2 (A3), Z5-6.10 (A3L), Z7-8.10 (A3L), Z80CPUOUT1.10, Z308.4
A4: Z0.6 (A4), Z1-2.8 (A4), Z3-4.1 (A4), Z5-6.11 (A4L), Z7-8.11 (A4L), Z80CPUOUT1.12, Z308.5
A5: Z0.7 (A5), Z1-2.7 (A5), Z3-4.44 (A5), Z5-6.12 (A5L), Z7-8.12 (A5L), Z80CPUOUT1.14, Z308.6
A6: Z0.8 (A6), Z1-2.6 (A6), Z3-4.43 (A6), Z5-6.13 (A6L), Z7-8.13 (A6L), Z80CPUOUT1.16, Z308.11
A7: Z0.9 (A7), Z1-2.5 (A7), Z3-4.42 (A7), Z5-6.14 (A7L), Z7-8.14 (A7L), Z80CPUOUT1.9, Z308.12
A8: D10.1 (K), Z0.10 (A8), Z1-2.27 (A8), Z3-4.39 (A8), Z5-6.15 (A8L), Z7-8.15 (A8L), Z80CPUOUT1.11, Z600.3 (A1)
A9: D9.1 (K), Z0.11 (A9), Z1-2.26 (A9), Z3-4.28 (A9), Z5-6.16 (A9L), Z7-8.16 (A9L), Z80CPUOUT1.13, Z600.2 (A0)
A10: CF1.18 (A2), CF2.18 (A2), CF3.18 (A2), CF4.18 (A2), D8.1 (K), Z0.12 (A10), Z1-2.23 (A10), Z3-4.27 (A10), Z80CPUOUT1.15, Z302.2, Z306.11
A11: CF1.19 (A1), CF2.19 (A1), CF3.19 (A1), CF4.19 (A1), D7.1 (K), Z0.13 (A11), Z1-2.25 (A11), Z3-4.26 (A11), Z80CPUOUT1.33, Z307.2 (A0)
A12: CF1.20 (A0), CF2.20 (A0), CF3.20 (A0), CF4.20 (A0), D6.1 (K), Z0.14 (A12), Z1-2.4 (A12), Z3-4.25 (A12), Z80CPUOUT1.31, Z307.3 (A1)
A13: D5.1 (K), Z0.16 (A13), Z1-2.28 (A13), Z3-4.24 (A13), Z29.1 (A0), Z80CPUOUT1.29
A14: D4.1 (K), D606.2 (A), Z0.17 (A14), Z1-2.29 (A14), Z3-4.23 (A14), Z29.2 (A1), Z80CPUOUT1.27
A15: D3.1 (K), D605.2 (A), Z0.18 (A15), Z1-2.2 (A16), Z3-4.22 (A15), Z29.3 (A2), Z80CPUOUT1.25
A16: D604.2 (A), Z0.19 (A16), Z1-2.3 (A15), Z3-4.21 (A16)
A17: D603.2 (A), Z0.20 (A17), Z3-4.20 (A17)
A18: D602.2 (A), Z0.21 (A18/TOUT), Z3-4.19 (A18)
A19: D601.2 (A), Z0.23 (A19), Z3-4.18 (A19)
CKS: J502.3, Z0.44 (CKS\~W\~REQB\~HTxRDY)
CNT0: Z22.5, Z303.9 (Q0)
CNT1: Z22.4, Z303.7 (Q1)
CNT2: Z22.3, Z303.6 (Q2)
DA0: CF1.21 (D0), CF2.21 (D0), CF3.21 (D0), CF4.21 (D0), Z0.24 (D0), Z1-2.13 (D0), Z3-4.9 (I/O0), Z5-6.17 (I/O0L), Z7-8.17 (I/O0L), Z14.3 (O1a), Z27.2 (D), Z80CPUOUT1.6
DA1: CF1.22 (D1), CF2.22 (D1), CF3.22 (D1), CF4.22 (D1), Z0.25 (D1), Z1-2.14 (D1), Z3-4.10 (I/O1), Z5-6.18 (I/O1L), Z7-8.18 (I/O1L), Z14.5 (O2a), Z80CPUOUT1.5
DA2: CF1.23 (D2), CF2.23 (D2), CF3.23 (D2), CF4.23 (D2), Z0.26 (D2), Z1-2.15 (D2), Z3-4.13 (I/O2), Z5-6.19 (I/O2L), Z7-8.19 (I/O2L), Z14.7 (O3a), Z80CPUOUT1.4
DA3: CF1.2 (D3), CF2.2 (D3), CF3.2 (D3), CF4.2 (D3), Z0.27 (D3), Z1-2.17 (D3), Z3-4.14 (I/O3), Z5-6.20 (I/O3L), Z7-8.20 (I/O3L), Z14.9 (O4a), Z80CPUOUT1.21
DA4: CF1.3 (D4), CF2.3 (D4), CF3.3 (D4), CF4.3 (D4), Z0.28 (D4), Z1-2.18 (D4), Z3-4.32 (I/O5), Z5-6.21 (I/O4L), Z7-8.21 (I/O4L), Z14.11 (O5b), Z80CPUOUT1.23
DA5: CF1.4 (D5), CF2.4 (D5), CF3.4 (D5), CF4.4 (D5), Z0.29 (D5), Z1-2.19 (D5), Z3-4.31 (I/O4), Z5-6.22 (I/O5L), Z7-8.22 (I/O5L), Z14.13 (O6b), Z80CPUOUT1.19
DA6: CF1.5 (D6), CF2.5 (D6), CF3.5 (D6), CF4.5 (D6), Z0.30 (D6), Z1-2.20 (D6), Z3-4.35 (I/O6), Z5-6.23 (I/O6L), Z7-8.23 (I/O6L), Z80CPUOUT1.3
DA7: CF1.6 (D7), CF2.6 (D7), CF3.6 (D7), CF4.6 (D7), Z0.31 (D7), Z1-2.21 (D7), Z3-4.36 (I/O7), Z5-6.24 (I/O7L), Z7-8.24 (I/O7L), Z80CPUOUT1.2
ENDOFSCR: Z20.2, Z25.2, Z304.12 (Q8)
EOL: Z21.11, Z22.13, Z25.3, Z303.12 (Q8), Z304.10 (CLK)
FONTCHAR0: Z7-8.45 (A0R), Z304.9 (Q0)
FONTCHAR1: Z7-8.44 (A1R), Z304.7 (Q1)
FONTCHAR2: Z7-8.43 (A2R), Z304.6 (Q2)
GND: AUDIO-IN1.2, AUDIO-OUT1.1, C2.2, C4.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C100.1, C101.1, C404.2, CF1.1 (GND), CF1.8 (A10), CF1.9 (~ATASEL), CF1.10 (A9), CF1.11 (A8), CF1.12 (A7), CF1.14 (A6), CF1.15 (A5), CF1.16 (A4), CF1.17 (A3), CF1.39 (~CSEL), CF1.50 (GND), CF2.1 (GND), CF2.8 (A10), CF2.9 (~ATASEL), CF2.10 (A9), CF2.11 (A8), CF2.12 (A7), CF2.14 (A6), CF2.15 (A5), CF2.16 (A4), CF2.17 (A3), CF2.39 (~CSEL), CF2.50 (GND), CF3.1 (GND), CF3.8 (A10), CF3.9 (~ATASEL), CF3.10 (A9), CF3.11 (A8), CF3.12 (A7), CF3.14 (A6), CF3.15 (A5), CF3.16 (A4), CF3.17 (A3), CF3.39 (~CSEL), CF3.50 (GND), CF4.1 (GND), CF4.8 (A10), CF4.9 (~ATASEL), CF4.10 (A9), CF4.11 (A8), CF4.12 (A7), CF4.14 (A6), CF4.15 (A5), CF4.16 (A4), CF4.17 (A3), CF4.39 (~CSEL), CF4.50 (GND), COMPOSITE-OUT1.2, IC1.2 (GND), J300.10, J301.10, J303.6, J304.10, J400.4, J400.5, J400.6, J400.7, J400.8, J400.9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
unnamed: AUDIO-IN1.1, C3.1, R5.2
unnamed: AUDIO-OUT1.2, C5.1, C6.1
unnamed: C1.1, Q1.3 (C), R1.2, R2.2, Z306.13
unnamed: C1.2, X1.2
unnamed: C2.1, Q1.2 (B), R2.1, X1.1
unnamed: C3.2, R6.2, Z14.14 (I6)
unnamed: C5.2, D2.2 (A), Q3.1 (C), R102.1
unnamed: C6.2, R10.2
unnamed: C100.2, X2.1, Z0.92 (EXTAL)
unnamed: C101.2, X2.2, Z0.91 (XTAL)
unnamed: C404.1, Z408.8 (VCAP)
unnamed: CF1.7 (~CS0), Z600.4 (O0)
unnamed: CF1.32 (~CS1), R601.2
unnamed: CF1.36 (~WE), R602.2
unnamed: CF1.44 (~DMACK), R603.2
unnamed: CF1.45 (~DASP), LED600.1 (K)
unnamed: CF1.46 (~PDIAG), R604.2
unnamed: CF2.7 (~CS0), Z600.5 (O1)
unnamed: CF2.32 (~CS1), R605.2
unnamed: CF2.36 (~WE), R606.2
unnamed: CF2.44 (~DMACK), R607.2
unnamed: CF2.45 (~DASP), LED602.1 (K)
unnamed: CF2.46 (~PDIAG), R608.2
unnamed: CF3.7 (~CS0), Z600.6 (O2)
unnamed: CF3.32 (~CS1), R611.2
unnamed: CF3.36 (~WE), R612.2
unnamed: CF3.44 (~DMACK), R613.2
unnamed: CF3.45 (~DASP), LED601.1 (K)
unnamed: CF3.46 (~PDIAG), R614.2
unnamed: CF4.7 (~CS0), Z600.7 (O3)
unnamed: CF4.32 (~CS1), R615.2
unnamed: CF4.36 (~WE), R616.2
unnamed: CF4.44 (~DMACK), R617.2
unnamed: CF4.45 (~DASP), LED604.1 (K)
unnamed: CF4.46 (~PDIAG), R618.2
unnamed: COMPOSITE-OUT1.1, RV1.2
unnamed: D3.2 (A), KEYBOARD1.15
unnamed: D4.2 (A), KEYBOARD1.13
unnamed: D5.2 (A), KEYBOARD1.11
unnamed: D6.2 (A), KEYBOARD1.9
unnamed: D7.2 (A), KEYBOARD1.7
unnamed: D8.2 (A), KEYBOARD1.5
unnamed: D9.2 (A), KEYBOARD1.3
unnamed: D10.2 (A), KEYBOARD1.1
unnamed: D11.1 (K), Z25.4
unnamed: D100.3 (K), Z306.8
unnamed: D601.1 (K), D602.1 (K), D603.1 (K), D604.1 (K), D605.1 (K), D606.1 (K), R621.1, Z306.1
unnamed: J400.2, Z408.6 (PA2)
unnamed: J400.3, Z408.5 (PA1)
unnamed: J400.11, Z408.12 (PB4)
unnamed: J400.12, Z408.11 (PB5)
unnamed: J402.1, Z408.17 (PC7)
unnamed: J402.2, Z408.3 (PD6)
unnamed: J402.3, Z408.16 (PC6)
unnamed: J402.4, Z408.2 (PD5)
unnamed: J402.5, Z408.15 (PC5)
unnamed: J402.6, Z408.1 (PD4)
unnamed: J402.7, Z408.10 (PA3)
unnamed: J402.8, Z408.20 (PD3)
unnamed: J402.9, Z408.18 (PD1)
unnamed: J402.10, Z408.19 (PD2)
unnamed: KEYBOARD1.2, Z14.2 (I1)
unnamed: KEYBOARD1.4, Z14.4 (I2)
unnamed: KEYBOARD1.6, Z14.6 (I3)
unnamed: KEYBOARD1.8, Z14.10 (I4)
unnamed: KEYBOARD1.10, Z14.12 (I5)
unnamed: LED600.2 (A), R609.2
unnamed: LED601.2 (A), R619.2
unnamed: LED602.2 (A), R610.2
unnamed: LED604.2 (A), R620.2
unnamed: Q3.2 (B), R9.1
unnamed: Q100.1 (E), R17.1, RV1.1
unnamed: R9.2, Z24.9, Z24.13
unnamed: R10.1, Z27.5 (Q)
unnamed: R11.2, Z23.3
unnamed: R100.2, Z5-6.4 (~INTL)
unnamed: R101.2, Z5-6.48 (~INTR)
unnamed: R102.2, SPK1.1
unnamed: R103.2, Z5-6.49 (~BUSYR)
unnamed: R104.2, Z7-8.4 (~INTL)
unnamed: R105.2, Z7-8.48 (~INTR)
unnamed: R106.2, Z7-8.3 (~BUSYL)
unnamed: R107.2, Z7-8.49 (~BUSYR)
unnamed: R108.2, Z5-6.3 (~BUSYL)
unnamed: Z5-6.27 (I/O0R), Z7-8.42 (A3R)
unnamed: Z5-6.28 (I/O1R), Z7-8.41 (A4R)
unnamed: Z5-6.29 (I/O2R), Z7-8.40 (A5R)
unnamed: Z5-6.30 (I/O3R), Z7-8.39 (A6R)
unnamed: Z5-6.31 (I/O4R), Z7-8.38 (A7R)
unnamed: Z5-6.32 (I/O5R), Z7-8.37 (A8R)
unnamed: Z5-6.33 (I/O6R), Z7-8.36 (A9R)
unnamed: Z14.1 (OEa), Z14.15 (OEb), Z306.6
unnamed: Z19.3, Z20.4
unnamed: Z19.5, Z20.6, Z20.12
unnamed: Z20.1, Z21.5, Z21.12
unnamed: Z20.3, Z304.11 (Reset)
unnamed: Z20.5, Z25.1
unnamed: Z20.8, Z27.11 (C)
unnamed: Z20.11, Z27.12 (D)
unnamed: Z21.8, Z303.11 (Reset)
unnamed: Z22.2, Z25.13
unnamed: Z22.12, Z25.5
unnamed: Z23.1, Z27.9 (Q)
unnamed: Z23.2, Z28.13 (Qh)
unnamed: Z24.1, Z24.8, Z27.3 (C)
unnamed: Z24.10, Z24.11
unnamed: Z24.4, Z24.12, Z306.5
unnamed: Z7-8.27 (I/O0R), Z28.1 (Ds)
unnamed: Z7-8.28 (I/O1R), Z28.2 (A)
unnamed: Z7-8.29 (I/O2R), Z28.3 (B)
unnamed: Z7-8.30 (I/O3R), Z28.4 (C)
unnamed: Z7-8.31 (I/O4R), Z28.5 (D)
unnamed: Z7-8.32 (I/O5R), Z28.10 (E)
unnamed: Z7-8.33 (I/O6R), Z28.11 (F)
unnamed: Z7-8.34 (I/O7R), Z28.12 (G)
unnamed: Z29.6 (E3), Z306.2
unnamed: Z29.7 (O7), Z407.6
unnamed: Z29.9 (O6), Z407.5
unnamed: Z29.10 (O5), Z407.4
unnamed: Z29.11 (O4), Z407.3
unnamed: Z29.12 (O3), Z407.2
unnamed: Z29.13 (O2), Z407.1
unnamed: Z29.14 (O1), Z307.1 (E)
unnamed: Z302.5, Z306.10
unnamed: Z306.4, Z308.1, Z308.2
unnamed: Z307.15 (E), Z308.8
PA0: J300.1, Z0.52 (PA0/HD0)
PA1: J300.3, Z0.53 (PA1/HD1)
PA2: J300.5, Z0.54 (PA2/HD2)
PA3: J300.7, Z0.55 (PA3/HD3)
PA4: J300.8, Z0.56 (PA4/HD3)
PA5: J300.6, Z0.57 (PA5/HD5)
PA6: J300.4, Z0.58 (PA6/HD6)
PA7: J300.2, Z0.59 (PA7/HD7)
PB0: J301.1, Z0.32 (~RTS0\PB0)
PB1: J301.3, Z0.33 (~CTS0\PB1)
PB2: J301.5, Z0.34 (~DCD0\PB2)
PB3: J301.7, Z0.35 (TxA0\PB3)
PB4: J301.8, Z0.36 (RxA0\PB4)
PB5: J301.6, Z0.37 (TxA1\PB5)
PB6: J301.4, Z0.38 (RxA1\PB6)
PC0: J501.1, Z0.64 (~DCDA/PC0)
PC1: J501.3, Z0.63 (~CTSA/PC1)
PC2: J501.5, Z0.62 (~MWR/PC2/RTSA)
PC3: J501.7, Z0.61 (~DTR\~REQA\PC3)
PC4: J501.8, Z0.65 (~SYNCA/PC4)
PC5: J501.6, Z0.60 (~W/~REQA/PC5)
PC6: J501.4, Z0.99 (~INT1/PC6)
RxDA: J303.2, Z0.71 (RxDA)
RxDB: J304.2, Z0.78 (RxDB/HA1), Z408.13 (PC3)
RxS\~CTS: J502.2, Z0.39 (RxS\~CTS1\PB7)
SCREENX0: Z5-6.45 (A0R), Z303.5 (Q3)
SCREENX1: Z5-6.44 (A1R), Z303.3 (Q4)
SCREENX2: Z5-6.43 (A2R), Z21.9, Z25.11, Z303.2 (Q5)
SCREENX3: Z5-6.42 (A3R), Z22.1, Z303.4 (Q6)
SCREENX4: Z5-6.41 (A4R), Z21.10, Z25.12, Z303.13 (Q7)
SCREENY0: Z5-6.40 (A5R), Z21.1, Z304.5 (Q3)
SCREENY1: Z5-6.39 (A6R), Z21.2, Z304.3 (Q4)
SCREENY2: Z5-6.38 (A7R), Z21.13, Z304.2 (Q5)
SCREENY3: Z5-6.37 (A8R), Z19.2, Z21.3, Z304.4 (Q6)
SCREENY4: Z5-6.36 (A9R), Z19.1, Z21.4, Z304.13 (Q7)
TxDA: J303.1, Z0.73 (TxDA)
TxDB: J304.1, Z0.76 (TxDB/~HDDIS), Z408.14 (PC4)
TxS: J502.1, Z0.43 (TxS\~DTR/~REQB/HINTR)
~0000-1FFF: Z29.15 (O0), Z404.1
~3000-37FF: Z307.6 (O2), Z404.4
~3800-3BFF: Z302.3, Z404.5
~3800-3FFF: Z302.1, Z302.4, Z307.7 (O3)
~CFCS: Z307.9 (O3), Z600.1 (E)
~CPUCLK: Z0.89 (PHI), Z80CPUOUT1.35
~CPUFONTRAM: Z7-8.1 (~CEL), Z302.11
~CPUFONTROM: Z302.8, Z404.2
~CPUVIDEORAM: Z5-6.1 (~CEL), Z307.4 (O0)
~CTSB: J304.6, Z0.75 (~CTSB/~HWR)
~DCDB: J304.4, Z0.74 (~DCDB/~HRD)
~INT0: Z0.98 (~INT0), Z80CPUOUT1.42
~INT2: D100.1 (A), Z0.100 (~INT2/PC7)
~IOREQ: Z0.83 (~IORQ), Z80CPUOUT1.34, Z306.3
~M1: Z0.86 (~M1), Z80CPUOUT1.20
~MREQ: Z0.84 (~MRD/~MREQ), Z29.4 (E1), Z29.5 (E2), Z80CPUOUT1.36
~NMI: Z0.97 (~NMI), Z80CPUOUT1.40
~RAMSEL: R32.1, Z3-4.6 (~CE1), Z407.8
~RD: CF1.34 (~IORD), CF2.34 (~IORD), CF3.34 (~IORD), CF4.34 (~IORD), Z0.88 (~RD), Z3-4.41 (~OE), Z5-6.6 (~OEL), Z7-8.6 (~OEL), Z24.6, Z80CPUOUT1.32, Z302.10
~RESET: C7.1, CF1.41 (~RESET), CF2.41 (~RESET), CF3.41 (~RESET), CF4.41 (~RESET), R25.2, Z0.96 (~RESET), Z80CPUOUT1.22, Z408.4 (NRST)
~RFSH: Z0.82 (~RFSH), Z80CPUOUT1.18
~ROMSEL: Z1-2.22 (CE), Z1-2.24 (OE), Z404.6
~RTSB: J304.8, Z0.47 (~TEND1/~RTSB/~HRxRDY)
~RTxCA: J303.4, Z0.66 (~RTxCA)
~RTxCB: J304.5, Z0.79 (~RTXCB/HA2)
~SYNCB: J304.7, Z0.80 (~SYNCB/~HCS)
~TAPECS: Z24.2, Z24.5, Z307.10 (O2)
~TRxCA: J303.3, Z0.72 (~TRxCA)
~TRxCB: J304.3, Z0.77 (~TRxCB/HA0)
~VIDEOCLK: Z20.10, Z28.7 (Clk), Z303.10 (CLK), Z306.12
~WR: CF1.35 (~IOWR), CF2.35 (~IOWR), CF3.35 (~IOWR), CF4.35 (~IOWR), Z0.87 (~WR), Z3-4.17 (~WE), Z5-6.2 (R~WL), Z7-8.2 (R~WL), Z24.3, Z80CPUOUT1.30, Z302.13

## KiCad design boards/funkeleinhorn__sc14cvmdect-devboard__audio_header/unrouted.kicad_pcb

Board: 4 copper layers, 30.0 x 50.0 mm, 34 parts (2 on the bottom side), 21 nets, no tracks yet.

Parts:
BK1: LOGO
C1, C2, C3, C6, C7: C; C_0603_1608Metric
C4, C5, C11: 0U1; C_0603_1608Metric
C8, C9, C12: 1N; C_0603_1608Metric
C10: 1U; C_0603_1608Metric
J1: Conn_01x18; PinSocket_1x18_P2.54mm_Vertical
J2: AudioJack4; Jack_3.5mm_CUI_SJ-4351X-SMT_Horizontal
J3: Screw_Terminal_01x02; TerminalBlock_MaiXu_MX126-5.0-02P_1x02_P5.00mm
LS1: Speaker; Speaker_CUI_CMR-15062S-67
MK1: Microphone; CUI_CMC-4013-SMT
R1, R2, R4, R5: 0R; R_0603_1608Metric
R3, R7, R10: 1K; R_0603_1608Metric
R6: 10R; R_0603_1608Metric
R8, R9: 1R; R_0603_1608Metric
kibuzzard-67A72E30: G***; kibuzzard-67A72E30
kibuzzard-67A72F6B: G***; kibuzzard-67A72F6B
kibuzzard-67A72F64: G***; kibuzzard-67A72F64
kibuzzard-67A72F83: G***; kibuzzard-67A72F83
kibuzzard-67A7302E: G***; kibuzzard-67A7302E
kibuzzard-67ACE384: G***; kibuzzard-67ACE384

Connections:
/Left: C12.1, J2.R1, J2.T
/Mic: C11.2, J2.S, R10.2
GND: C1.1, C2.1, C7.2, C8.2, C9.1, C10.2, J1.2, J2.R2, R7.1
unnamed: C1.2, C3.1, LS1.1, R1.2
unnamed: C2.2, C3.2, LS1.2, R2.2
unnamed: C4.1, R4.2
unnamed: C4.2, C7.1, R3.2, R6.1
unnamed: C5.1, R5.2
unnamed: C8.1, R8.2
unnamed: C9.2, R9.1
unnamed: J1.4, R3.1, R10.1
unnamed: J1.5, R5.1
unnamed: J1.6, R4.1
unnamed: C11.1, J1.7
unnamed: C12.2, J1.8, R1.1
unnamed: J1.9, R2.1
unnamed: J1.12, J3.1, R8.1
unnamed: J1.13, J3.2, R9.2
unnamed: C5.2, C6.2, MK1.2 (+), R7.2
unnamed: C6.1, MK1.1 (-), R6.2
VCC: C10.1, J1.1, J1.3

## KiCad design boards/funkeleinhorn__sc14cvmdect-devboard__sc14cvmdect-devboard/unrouted.kicad_pcb

Board: 4 copper layers, 80.0 x 90.0 mm, 92 parts (2 on the bottom side), 54 nets, no tracks yet.

Parts:
C1, C4, C5: 2u2; C_0805_2012Metric
C2, C3, C9: 47p; C_0603_1608Metric
C6: 10u; C_0805_2012Metric
C7, C8: 100n; C_0603_1608Metric
D1: OSK40603C1E; LED_0603_1608Metric
D2: ORH-B36G; LED_0603_1608Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_DIN965
J1: Conn_01x08; PinHeader_1x08_P2.54mm_Vertical
J2: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_JAE_DX07S016JA1R1500
J3: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J4, J6: Conn_01x18; PinHeader_1x18_P2.54mm_Vertical
R1, R2, R3: 5K1; R_0603_1608Metric
R4, R5: 27R; R_0603_1608Metric
R6: 1K; R_0603_1608Metric
R7, R8: 470R; R_0603_1608Metric
SW1: SW_Push; SW_SPST_PTS647_Sx70
U1: TLV1117LV33; SOT-223-3_TabPin2
U2: SC14CVMDECT
U3: FT230XQ; QFN-16-1EP_4x4mm_P0.65mm_EP2.1x2.1mm
U4: MIC5317-1.8xM5; SOT-23-5
kibuzzard-676BF11C: G***; kibuzzard-676BF11C
kibuzzard-67575DB5: G***; kibuzzard-67575DB5
kibuzzard-67575DD6: G***; kibuzzard-67575DD6
kibuzzard-67575DF0: G***; kibuzzard-67575DF0
kibuzzard-67575E60: G***; kibuzzard-67575E60
kibuzzard-67575EB8: G***; kibuzzard-67575EB8
kibuzzard-67575F62: G***; kibuzzard-67575F62
kibuzzard-67575F78: G***; kibuzzard-67575F78
kibuzzard-67576AD7: G***; kibuzzard-67576AD7
kibuzzard-67576C4F: G***; kibuzzard-67576C4F
kibuzzard-67576C6D: G***; kibuzzard-67576C6D
kibuzzard-67576C73: G***; kibuzzard-67576C73
kibuzzard-67576CB2: G***; kibuzzard-67576CB2
kibuzzard-675753CF: G***; kibuzzard-675753CF
kibuzzard-675756D3: G***; kibuzzard-675756D3
kibuzzard-675758CB: G***; kibuzzard-675758CB
kibuzzard-675760A1: G***; kibuzzard-675760A1
kibuzzard-675760B0: G***; kibuzzard-675760B0
kibuzzard-675761BC: G***; kibuzzard-675761BC
kibuzzard-675761D3: G***; kibuzzard-675761D3
kibuzzard-675761E9: G***; kibuzzard-675761E9
kibuzzard-675763C9: G***; kibuzzard-675763C9
kibuzzard-675763D6: G***; kibuzzard-675763D6
kibuzzard-675763F4: G***; kibuzzard-675763F4
kibuzzard-675764D8: G***; kibuzzard-675764D8
kibuzzard-675765AC: G***; kibuzzard-675765AC
kibuzzard-675765C1: G***; kibuzzard-675765C1
kibuzzard-675765D1: G***; kibuzzard-675765D1
kibuzzard-6757604E: G***; kibuzzard-6757604E
kibuzzard-6757607D: G***; kibuzzard-6757607D
kibuzzard-6757616E: G***; kibuzzard-6757616E
kibuzzard-6757620D: G***; kibuzzard-6757620D
kibuzzard-6757621E: G***; kibuzzard-6757621E
kibuzzard-6757634F: G***; kibuzzard-6757634F
kibuzzard-6757635E: G***; kibuzzard-6757635E
kibuzzard-6757636C: G***; kibuzzard-6757636C
kibuzzard-6757638A: G***; kibuzzard-6757638A
kibuzzard-6757639A: G***; kibuzzard-6757639A
kibuzzard-6757652F: G***; kibuzzard-6757652F
kibuzzard-6757657B: G***; kibuzzard-6757657B
kibuzzard-6757659F: G***; kibuzzard-6757659F
kibuzzard-6757660D: G***; kibuzzard-6757660D
kibuzzard-6757661A: G***; kibuzzard-6757661A
kibuzzard-6757663B: G***; kibuzzard-6757663B
kibuzzard-67575390: G***; kibuzzard-67575390
kibuzzard-67575747: G***; kibuzzard-67575747
kibuzzard-67576033: G***; kibuzzard-67576033
kibuzzard-67576075: G***; kibuzzard-67576075
kibuzzard-67576138: G***; kibuzzard-67576138
kibuzzard-67576147: G***; kibuzzard-67576147
kibuzzard-67576184: G***; kibuzzard-67576184
kibuzzard-67576478: G***; kibuzzard-67576478
kibuzzard-67576487: G***; kibuzzard-67576487
kibuzzard-67576490: G***; kibuzzard-67576490
kibuzzard-67576547: G***; kibuzzard-67576547
kibuzzard-67576569: G***; kibuzzard-67576569
kibuzzard-67576627: G***; kibuzzard-67576627
kibuzzard-67576652: G***; kibuzzard-67576652
kibuzzard-67576660: G***; kibuzzard-67576660

Connections:
+3V3: C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, J1.1, J4.1, J6.1, R6.2, R7.1, R8.2, U1.2 (VO), U2.29 (PON), U2.63 (VBATIN), U2.64 (VBATIN), U3.8 (3V3OUT), U3.9 (~RESET), U3.10 (VCC), U4.1 (VIN), U4.3 (EN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), J4.2, J4.3, J6.2, R2.2, R3.2, SW1.1, U1.1 (GND), U2.1 (GND), U2.6 (GND), U2.11 (VREFm), U2.14 (GND), U2.17 (SOCp), U2.18 (SOCn), U2.19 (DC_SENSE), U2.20 (DC_I), U2.28 (GND), U2.30 (ULP_XTAL), U2.31 (ULP_PORT), U2.38 (GND), U2.45 (GND), U2.49 (GND), U2.50 (GND), U2.51 (GND), U2.60 (GND), U2.70 (GND), U2.71 (GND), U2.72 (GND), U2.74 (GND), U2.76 (GND), U2.77 (GND), U2.78 (GND), U2.80 (GND), U3.3 (GND), U3.13 (GND), U3.17 (GND), U4.2 (GND)
unnamed: C2.1, J2.A7 (D-), J2.B7 (D-), R4.1
unnamed: C3.1, J2.A6 (D+), J2.B6 (D+), R5.1
unnamed: D1.2 (A), R7.2
unnamed: D1.1 (K), J4.17, U2.58 (LED4)
unnamed: D2.2 (A), R8.1
unnamed: D2.1 (K), J4.18, U2.59 (LED3)
unnamed: J1.2, U2.32 (BXTAL)
unnamed: J1.3, U2.33 (VDDE)
unnamed: J1.4, U2.34 (TDOD)
unnamed: J1.5, U2.35 (SIO)
unnamed: J1.6, U2.36 (SK)
unnamed: J1.7, U2.37 (LE)
unnamed: J1.8, U2.39 (WTF_IN)
unnamed: J2.A5 (CC1), R3.1
unnamed: J2.B5 (CC2), R2.1
unnamed: J3.2, U3.14 (CBUS3)
unnamed: J3.3, R1.1, SW1.2
unnamed: J4.4, U2.53 (JTAG)
unnamed: J4.5, U2.40 (SPI_DI)
unnamed: J4.6, U2.41 (SPI_DO)
unnamed: J4.7, U2.42 (SPI_CLK)
unnamed: J4.8, U2.43 (SPI_EN)
unnamed: J4.9, U2.44 (SCL2)
unnamed: J4.10, U2.46 (SDA2)
unnamed: J4.11, U2.47 (URX), U3.15 (TXD)
unnamed: J4.12, U2.48 (UTX), U3.2 (RXD)
unnamed: J4.13, U2.54 (PCM_FSC)
unnamed: J4.14, U2.55 (PCM_DO)
unnamed: J4.15, U2.56 (PCM_DI)
unnamed: J4.16, U2.57 (PCM_CLK)
unnamed: J6.3, U2.25 (VDDPA)
unnamed: J6.4, U2.7 (VREFp)
unnamed: J6.5, U2.8 (MICp)
unnamed: J6.6, U2.9 (MICn)
unnamed: J6.7, U2.10 (MICh)
unnamed: J6.8, U2.12 (LSRp)
unnamed: J6.9, U2.13 (LSRn)
unnamed: J6.10, U2.15 (ADC0)
unnamed: J6.11, U2.16 (ADC1)
unnamed: J6.12, U2.24 (PAOUTp)
unnamed: J6.13, U2.27 (PAOUTn)
unnamed: J6.14, U2.65 (CIDINp)
unnamed: J6.15, U2.66 (RINGp)
unnamed: J6.16, U2.67 (RINGn)
unnamed: J6.17, U2.68 (RINGING)
unnamed: J6.18, U2.69 (PARADET)
unnamed: R6.1, U2.23 (CHARGE)
unnamed: R1.2, U2.52 (RSTn)
unnamed: R4.2, U3.7 (USBDM)
unnamed: R5.2, U3.6 (USBDP)
unnamed: U3.1 (VCCIO), U4.5 (VOUT)
VBUS: C1.1, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), U1.3 (VI)

## KiCad design boards/fxkuehl__mantis__mantis/unrouted.kicad_pcb

Board: 2 copper layers, 220.0 x 129.3 mm, 82 parts (0 on the bottom side), 56 nets, no tracks yet.

Parts:
B1: SW_TACT_ALPS_SKQGABE010
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40: ComboDiode
MCU1: ProMicro
S1, S2, S3, S4, S5, S6, S7, S8, S9, S10, S11, S12, S13, S14, S15, S16, S17, S18, S19, S20, S21, S22, S23, S24, S25, S26, S27, S28, S29, S30, S31, S32, S33, S34, S35, S36, S37, S38, S39, S40: PG1350

Connections:
GND: B1.1, MCU1.2, MCU1.15, MCU1.16
P0: D2.1, D5.1, D8.1, D11.1, D14.1, D22.1, D25.1, D28.1, D31.1, D34.1, MCU1.14
P1: D3.1, D6.1, D9.1, D12.1, D15.1, D23.1, D26.1, D29.1, D32.1, D35.1, MCU1.13
P2: D1.1, D4.1, D7.1, D10.1, D13.1, D21.1, D24.1, D27.1, D30.1, D33.1, MCU1.17
P3: D16.1, D17.1, D18.1, D19.1, D20.1, D36.1, D37.1, D38.1, D39.1, D40.1, MCU1.18
P4: MCU1.19, S21.2, S22.2, S23.2, S36.2
P5: MCU1.20, S24.2, S25.2, S26.2, S37.2
P6: MCU1.21, S27.2, S28.2, S29.2, S38.2
P7: MCU1.22, S30.2, S31.2, S32.2, S39.2
P8: MCU1.23, S33.2, S34.2, S35.2, S40.2
P14: MCU1.10, S10.2, S11.2, S12.2, S19.2
P15: MCU1.9, S7.2, S8.2, S9.2, S18.2
P16: MCU1.11, S13.2, S14.2, S15.2, S20.2
P18: MCU1.8, S4.2, S5.2, S6.2, S17.2
P19: MCU1.7, S1.2, S2.2, S3.2, S16.2
RST: B1.2, MCU1.3
c1_r1: D1.2, S1.1
c1_r2: D2.2, S2.1
c1_r3: D3.2, S3.1
c1_rt: D16.2, S16.1
c1m_r1: D21.2, S21.1
c1m_r2: D22.2, S22.1
c1m_r3: D23.2, S23.1
c1m_rt: D36.2, S36.1
c2_r1: D4.2, S4.1
c2_r2: D5.2, S5.1
c2_r3: D6.2, S6.1
c2_rt: D17.2, S17.1
c2m_r1: D24.2, S24.1
c2m_r2: D25.2, S25.1
c2m_r3: D26.2, S26.1
c2m_rt: D37.2, S37.1
c3_r1: D7.2, S7.1
c3_r2: D8.2, S8.1
c3_r3: D9.2, S9.1
c3_rt: D18.2, S18.1
c3m_r1: D27.2, S27.1
c3m_r2: D28.2, S28.1
c3m_r3: D29.2, S29.1
c3m_rt: D38.2, S38.1
c4_r1: D10.2, S10.1
c4_r2: D11.2, S11.1
c4_r3: D12.2, S12.1
c4_rt: D19.2, S19.1
c4m_r1: D30.2, S30.1
c4m_r2: D31.2, S31.1
c4m_r3: D32.2, S32.1
c4m_rt: D39.2, S39.1
c5_r1: D13.2, S13.1
c5_r2: D14.2, S14.1
c5_r3: D15.2, S15.1
c5_rt: D20.2, S20.1
c5m_r1: D33.2, S33.1
c5m_r2: D34.2, S34.1
c5m_r3: D35.2, S35.1
c5m_rt: D40.2, S40.1

Notices in the files:
boards/flypie__Ace-2019__acez180/unrouted.kicad_pcb:
https://creativecommons.org/licenses/by-nc-sa/4.0
This work is licensed under a Creative Commons
