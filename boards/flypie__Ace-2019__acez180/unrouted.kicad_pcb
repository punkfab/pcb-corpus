# Repository punkfab/pcb-corpus (continued)

## KiCad design boards/fxkuehl__mantis__mantis_raised_leds/unrouted.kicad_pcb

Board: 2 copper layers, 131.5 x 107.5 mm, 59 parts (2 on the bottom side), 52 nets, no tracks yet.

Parts:
B1: SW_TACT_ALPS_SKQGABE010
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16: SOD123-back
Direct: SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16: SK6812_MINI-E-back
LED level shifter: DIP-14_W7.62mm
MCU1: ProMicro-back
MCU2: Connector-20pin
PAD1, PAD2, PAD3, PAD4, PAD5, PAD6: MountingHole_2.2mm_M2_Pad_Via
S1, S2, S3, S4, S5, S6, S7, S8, S9, S10, S11, S12, S13, S14, S15, S16: PG1350

Connections:
C1: MCU1.19, MCU2.19
C2: MCU1.20, MCU2.20
C3: MCU1.21, MCU2.21
C4: MCU1.22, S1.1, S3.1, S5.1, S7.1
C5: MCU1.23, S2.1, S4.1, S6.1, S8.1
GND: B1.1, LED1.3, LED2.3, LED3.3, LED4.3, LED5.3, LED6.3, LED7.3, LED8.3, LED9.3, LED10.3, LED11.3, LED12.3, LED13.3, LED14.3, LED15.3, LED16.3, LED level shifter.7, MCU1.2, MCU1.15, MCU1.16, PAD1.1, PAD2.1, PAD3.1, PAD4.1, PAD5.1, PAD6.1
LED: Direct.1, LED level shifter.1, MCU1.24
M_C1: MCU1.7, MCU2.7
M_C2: MCU1.8, MCU2.8
M_C3: MCU1.9, MCU2.9
M_C4: MCU1.10, S9.1, S11.1, S13.1, S15.1
M_C5: MCU1.11, S10.1, S12.1, S14.1, S16.1
R1: D5.1, D6.1, D13.1, D14.1, MCU1.17, MCU2.10, MCU2.17
R2: D3.1, D4.1, D11.1, D12.1, MCU1.14, MCU2.6, MCU2.14
R3: D1.1, D2.1, D9.1, D10.1, MCU1.13, MCU2.5, MCU2.13
RST: B1.2, MCU1.3
RT: D7.1, D8.1, D15.1, D16.1, MCU1.18, MCU2.11, MCU2.18
VCC: LED1.1, LED2.1, LED3.1, LED4.1, LED5.1, LED6.1, LED7.1, LED8.1, LED9.1, LED10.1, LED11.1, LED12.1, LED13.1, LED14.1, LED15.1, LED16.1, LED level shifter.14, MCU1.1, MCU2.4, MCU2.22
c4_r1: D5.2, S5.2
c4_r2: D3.2, S3.2
c4_r3: D1.2, S1.2
c4_rt: D7.2, S7.2
c5_r1: D6.2, S6.2
c5_r2: D4.2, S4.2
c5_r3: D2.2, S2.2
c5_rt: D8.2, S8.2
di_c4_r1: LED5.4, LED7.2
di_c4_r2: LED1.2, LED3.4
di_c4_r3: Direct.2, LED1.4, LED level shifter.4
di_c4_rt: LED7.4, LED8.2
di_c5_r1: LED6.4, LED14.2
di_c5_r2: LED4.4, LED5.2
di_c5_r3: LED2.4, LED3.2
di_c5_rt: LED6.2, LED8.4
di_mirror_c3_r3: MCU2.12, MCU2.24
di_mirror_c4_r1: LED12.2, LED13.4
di_mirror_c4_r2: LED9.2, LED11.4
di_mirror_c4_r3: LED9.4, LED10.2
di_mirror_c4_rt: LED13.2, LED15.4
di_mirror_c5_r1: LED14.4, LED16.2
di_mirror_c5_r2: LED11.2, LED12.4
di_mirror_c5_r3: LED2.2, LED10.4
di_mirror_c5_rt: LED15.2, LED16.4
do_c5_r2: LED4.2, MCU2.23
mirror_c4_r1: D13.2, S13.2
mirror_c4_r2: D11.2, S11.2
mirror_c4_r3: D9.2, S9.2
mirror_c4_rt: D15.2, S15.2
mirror_c5_r1: D14.2, S14.2
mirror_c5_r2: D12.2, S12.2
mirror_c5_r3: D10.2, S10.2
mirror_c5_rt: D16.2, S16.2

## KiCad design boards/galopago__misistemita__C12/unrouted.kicad_pcb

Board: 2 copper layers, 38.1 x 48.3 mm, 54 parts (41 on the bottom side), 61 nets, no tracks yet.

Parts:
HB0, HB3: MountingHole; MountingHole_3mm
HD0, HD3: MountingHole; MountingHole_3mm
J1, J2, J3, J4: Conn_01x10_Female; PinHeader_1x10_P2.54mm_Vertical
J5, J6: Conn_01x10_Female; TerminalBlock_4Ucon_1x10_P3.50mm_Vertical
J10, J11: Conn_01x01_Male; SolderWirePad_1x01_Drill1mm
JP1, JP2, JP3, JP4, JP5, JP6, JP7, JP8, JP9, JP10, JP21, JP22, JP23, JP24, JP25, JP26, JP27, JP28, JP29, JP30: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP11, JP12, JP13, JP14, JP15, JP16, JP17, JP18, JP19, JP20, JP31, JP32, JP33, JP34, JP35, JP36, JP37, JP38, JP39, JP40: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
REFS0**: OSHW-Symbol_6.7x6mm_Copper
REFS1**: OSHW-Symbol_6.7x6mm_SilkScreen

Connections:
unnamed: J1.1, JP1.2 (B)
unnamed: J1.2, JP2.2 (B)
unnamed: J1.3, JP3.2 (B)
unnamed: J1.4, JP4.2 (B)
unnamed: J1.5, JP5.2 (B)
unnamed: J1.6, JP6.2 (B)
unnamed: J1.7, JP7.2 (B)
unnamed: J1.8, JP8.2 (B)
unnamed: J1.9, JP9.2 (B)
unnamed: J1.10, JP10.2 (B)
unnamed: J2.1, JP21.1 (A)
unnamed: J2.2, JP22.1 (A)
unnamed: J2.3, JP23.1 (A)
unnamed: J2.4, JP24.1 (A)
unnamed: J2.5, JP25.1 (A)
unnamed: J2.6, JP26.1 (A)
unnamed: J2.7, JP27.1 (A)
unnamed: J2.8, JP28.1 (A)
unnamed: J2.9, JP29.1 (A)
unnamed: J2.10, JP30.1 (A)
unnamed: J3.1, JP11.2 (B)
unnamed: J3.2, JP12.2 (B)
unnamed: J3.3, JP13.2 (B)
unnamed: J3.4, JP14.2 (B)
unnamed: J3.5, JP15.2 (B)
unnamed: J3.6, JP16.2 (B)
unnamed: J3.7, JP17.2 (B)
unnamed: J3.8, JP18.2 (B)
unnamed: J3.9, JP19.2 (B)
unnamed: J3.10, JP20.2 (B)
unnamed: J4.1, JP31.1 (A)
unnamed: J4.2, JP32.1 (A)
unnamed: J4.3, JP33.1 (A)
unnamed: J4.4, JP34.1 (A)
unnamed: J4.5, JP35.1 (A)
unnamed: J4.6, JP36.1 (A)
unnamed: J4.7, JP37.1 (A)
unnamed: J4.8, JP38.1 (A)
unnamed: J4.9, JP39.1 (A)
unnamed: J4.10, JP40.1 (A)
unnamed: J10.1, J11.1
unnamed: J5.10, JP1.1 (A), JP11.1 (A)
unnamed: J5.1, JP10.1 (A), JP20.1 (A)
unnamed: J5.9, JP2.1 (A), JP12.1 (A)
unnamed: J5.8, JP3.1 (A), JP13.1 (A)
unnamed: J5.7, JP4.1 (A), JP14.1 (A)
unnamed: J5.6, JP5.1 (A), JP15.1 (A)
unnamed: J5.5, JP6.1 (A), JP16.1 (A)
unnamed: J5.4, JP7.1 (A), JP17.1 (A)
unnamed: J5.3, JP8.1 (A), JP18.1 (A)
unnamed: J5.2, JP9.1 (A), JP19.1 (A)
unnamed: J6.10, JP21.2 (B), JP31.2 (B)
unnamed: J6.9, JP22.2 (B), JP32.2 (B)
unnamed: J6.8, JP23.2 (B), JP33.2 (B)
unnamed: J6.7, JP24.2 (B), JP34.2 (B)
unnamed: J6.6, JP25.2 (B), JP35.2 (B)
unnamed: J6.5, JP26.2 (B), JP36.2 (B)
unnamed: J6.4, JP27.2 (B), JP37.2 (B)
unnamed: J6.3, JP28.2 (B), JP38.2 (B)
unnamed: J6.2, JP29.2 (B), JP39.2 (B)
unnamed: J6.1, JP30.2 (B), JP40.2 (B)

## KiCad design boards/gcormier__megadesk__megadesk/unrouted.kicad_pcb

Board: 2 copper layers, 41.7 x 32.2 mm, 28 parts (4 on the bottom side), 24 nets, no tracks yet.

Parts:
BZ1: Buzzer; Buzzer_Murata_PKMCS0909E
C1, C2, C6: 220pF; C_0603_1608Metric
C3, C4, C5: 0.1uF; C_0805_2012Metric
D1, D2: 1N4148; D_SOD-323
D3: SMF33A; D_SOD-123F
J2: FFC; F1004-H-10-20G-R
J3: AVR-ISP-6; PinHeader_2x03_P2.54mm_Vertical
J4: Interface; PinHeader_1x05_P2.54mm_Horizontal
R1, R2, R6, R7: 1k; R_0603_1608Metric
R3, R4, R5: 4.7k; R_0603_1608Metric
TP1, TP2: TestPoint; TestPoint_Pad_D1.5mm
TP3: TPDN; TestPoint_Pad_D1.5mm
TP4: TPUP; TestPoint_Pad_D1.5mm
U1: 7812; TO-252-2
U2: HT7550-1; SOT-89-3
U3: ATtiny841-SS; SOIC-14_3.9x8.7mm_P1.27mm
U4: MCP2003B; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C4.1, C5.1, J3.2 (VCC), R3.1, R4.2, U2.3 (VO), U3.1 (VCC)
+12V: C2.1, C3.1, D1.2 (A), U1.3 (OUT), U2.2 (VI)
+24V: C1.1, D3.1 (K), J4.1, U1.1 (IN)
/AVRRX: J4.4, R2.2
/AVRTX: J4.5, R7.2
/MISO: J3.1 (MISO), R7.1, U3.8 (PA5)
/MOSI: J3.4 (MOSI), U3.7 (PA6)
/RST: J3.5 (~RST), U3.4 (~RESET/PB3)
/SCK: J3.3 (SCK), R2.1, U3.9 (PA4)
B9: J2.9, U3.13 (AREF/PA0)
B10: J2.10, U3.10 (PA3)
Bdown: J2.6, TP3.1, U3.3 (XTAL2/PB1)
Bup: J2.5, TP4.1, U3.2 (XTAL1/PB0)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, D3.2 (A), J2.7, J3.6 (GND), J4.2, R1.2, R5.2, U1.2 (GND), U2.1 (GND), U3.14 (GND), U4.5 (VSS)
LINBUS: C6.1, J4.3, R6.2, U4.6 (LBUS)
unnamed: BZ1.2 (+), R1.1
unnamed: BZ1.1 (-), U3.6 (PA7)
unnamed: D1.1 (K), D2.2 (A), U4.7 (VBB)
unnamed: D2.1 (K), R6.1
unnamed: TP1.1, TP2.1
unnamed: U3.12 (PA1), U4.4 (TXD)
unnamed: R3.2, U3.11 (PA2), U4.1 (RXD)
unnamed: R4.1, U4.2 (CS)
unnamed: R5.1, U4.3 (WAKE)

## KiCad design boards/ikajdan__reflow-hot-plate__control_board/unrouted.kicad_pcb

Board: 2 copper layers, 80.0 x 80.0 mm, 123 parts (18 on the bottom side), 77 nets, no tracks yet.

Parts:
BZ1: Buzzer; CMI-9605IC-0380T
C1, C2: 10p; C_0603_1608Metric
C3, C4, C5, C6, C8, C10, C11, C15, C16, C18, C19, C20, C21, C22, C23: 100n; C_0603_1608Metric
C7, C14, C17: 1u; C_0603_1608Metric
C9: 4u7; C_0603_1608Metric
C12, C13: 22u; C_0603_1608Metric
D1: 5V6; D_SOD-123F
D2, D3: Green; LED_0603_1608Metric
D4: MBR1020VL; D_SOD-123F
D5, D6, D7, D8: Yellow; LED_0603_1608Metric
D9: 15V; D_SOD-123F
D10: SKL310; D_SOD-123F
F1: 500mA; MINISMDCx
F2: 10A; Fuseholder_Cylinder-5x20mm_Schurter_0031_8201_Horizontal_Op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
FB1, FB2: 470R; L_0603_1608Metric
FID1: Fiducial; Fiducial_1mm_Mask2mm
H1, H2, H3, H4: 2.5mm; MountingHole_2.5mm
HS1: 217-36CTE6; 217-36CTx6
J1: SWD; PinHeader_1x06_P2.54mm_Vertical
J2: Aux; PinHeader_2x05_P2.54mm_Vertical
J3: Panel; 52808-1070
J4: 6.5/2mm; BarrelJack_CUI_PJ-063AH_Horizontal
J5: USB_C; USB4105-GF-A
J6: RTD; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J7: TC; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J8, J9: Conn_01x01; Pad_D5mm_H2.2mm_Via
L1: 10u; L_0603_1608Metric
L2: 15u; SRN6028Cx
NT1, NT2: NetTie_2; NetTie-2_SMD_Pad0.2mm
Q1: 2N7002A; SOT-23
Q2: IRF1018ESTRLPBF; TO-263-2
R1, R2, R3, R4, R5, R6, R18: 10k; R_0603_1608Metric
R7, R8, R9, R10, R17, R28, R33: 100R; R_0603_1608Metric
R11: 270R; R_0603_1608Metric
R12: 25k5; R_0603_1608Metric
R13: 100k; R_0603_1608Metric
R14: 24k9; R_0603_1608Metric
R15: 2k2; R_0603_1608Metric
R16, R19, R20, R21, R22: 120R; R_0603_1608Metric
R23: 1k47; R_0603_1608Metric
R24, R25: 5k1; R_0603_1608Metric
R26, R27, R30, R34, R35: 1k; R_0603_1608Metric
R29: 4k99; R_0603_1608Metric
R31, R32: 3k3; R_0603_1608Metric
SW1: Reset; SW_SPST_B3U-1000P
SW2: Power; SwitchWireRelief
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP17, TP18: TestPoint_Small; TestPoint_Pad_D1.0mm
U1: STM32F103CBT6; LQFP-48_7x7mm_P0.5mm
U2: LMR38010SDDAR; TI_SO-PowerPAD-8_ThermalVias
U3: TLV76133DCYR; SOT-223-3_TabPin2
U4: USBLC6-2SC6; SOT-23-6
U5: MAX6675; SOIC-8_3.9x4.9mm_P1.27mm
U6: MCP6N11T-005E; SOIC-8_3.9x4.9mm_P1.27mm
U7: MCP6001T; SOT-23-5
U8: TLP183; SOIC-4_4.55x3.7mm_P2.54mm
Y1: 8MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: BZ1.1, C16.1, C17.1, C19.1, C22.1, C23.1, D4.1 (K), FB1.2, J2.1, J3.10, L1.1, R3.1, R4.1, R5.1, R6.1, R16.1, R26.1, R27.1, TP10.1, U3.2 (VO), U5.4 (VCC), U6.7 (V+), U6.8 (EN), U7.5 (V+)
+5V: C12.1, C13.1, C14.1, C15.1, D1.1 (K), FB2.1, L2.2, R13.1, TP9.1, U3.3 (VI)
+24V: D10.1 (K), F1.1, J8.1, NT1.2, NT2.2, SW2.2 (B)
/BUTTON_DOWN: R7.1, U1.3 (PC14)
/BUTTON_LEFT: R10.1, U1.45 (PB8)
/BUTTON_RIGHT: R9.1, U1.46 (PB9)
/BUTTON_UP: R8.1, U1.2 (PC13)
/BUZZER: R17.2, U1.4 (PC15)
/HEATBED: R33.1, U1.40 (PB4)
/HSE_IN: C1.1, U1.5 (PD0), Y1.1
/HSE_OUT: C2.1, U1.6 (PD1), Y1.3
/I2C2_SCL: J2.2, R5.2, U1.21 (PB10)
/I2C2_SDA: J2.3, R6.2, U1.22 (PB11)
/LCD_SCL: J3.4, R3.2, TP3.1, U1.42 (PB6)
/LCD_SDA: J3.2, R4.2, TP4.1, U1.43 (PB7)
/LED_COOLING: R22.1, U1.20 (PB2)
/LED_PREHEAT: R19.1, U1.17 (PA7)
/LED_REFLOW: R21.1, U1.19 (PB1)
/LED_SOAK: R20.1, U1.18 (PB0)
/LED_STATUS: R11.1, U1.41 (PB5)
/NRST: C3.1, J1.5, R1.2, SW1.2, U1.7 (NRST)
/PT: C21.2, TP16.1, U1.11 (PA1), U7.1, U7.4 (-)
/Power Supply/FB: R13.2, R14.1, TP8.1, U2.5 (FB)
/Power Supply/RT: R12.1, TP6.1, U2.4 (RT/SYNC)
/Power Supply/SW: C11.2, L2.1, TP7.1, U2.8 (SW)
/Power Supply/VIN: C9.1, C10.1, F1.2, TP5.1, U2.2 (EN), U2.3 (VIN)
/SPI2_MISO: J2.7, U1.27 (PB14)
/SPI2_MOSI: J2.9, U1.28 (PB15)
/SPI2_SCK: J2.8, U1.26 (PB13)
/SPI2_~CS: J2.6, U1.25 (PB12)
/SWCLK: J1.2, U1.37 (PA14)
/SWDIO: J1.4, U1.34 (PA13)
/SWO: J1.6, U1.39 (PB3)
/TC_SCK: U1.15 (PA5), U5.5 (SCK)
/TC_SO: U1.16 (PA6), U5.7 (SO)
/TC_~CS: U1.14 (PA4), U5.6 (~CS)
/Temperature Sensors/IN+: J6.1, R26.2, TP11.1, U6.3 (+)
/Temperature Sensors/IN-: R27.2, R28.1, TP12.1, U6.2 (-)
/USB Connector/DATA+: J5.A6 (D+), J5.B6 (D+), U4.3 (I/O2)
/USB Connector/DATA-: J5.A7 (D-), J5.B7 (D-), U4.1 (I/O1)
/USB Connector/VBUS: C18.1, FB2.2, J5.A4 (VBUS), J5.A9 (VBUS), J5.B4 (VBUS), J5.B9 (VBUS), U4.5 (VBUS)
/USB_D+: R23.2, U1.33 (PA12), U4.4 (I/O2)
/USB_D-: U1.32 (PA11), U4.6 (I/O1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C22.2, C23.2, D1.2 (A), D2.1 (K), D3.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.2 (A), J1.3, J2.10, J3.1, J3.3, J4.2, J4.MP (MountPin), J5.A1 (GND), J5.A12 (GND), J5.B1 (GND), J5.B12 (GND), J5.S1 (SHIELD), J6.3, J7.2, Q1.2 (S), Q2.3 (S), R2.1, R12.2, R14.2, R18.1, R24.1, R25.1, R30.1, R35.2, SW1.1, U1.8 (VSSA), U1.23 (VSS), U1.35 (VSS), U1.47 (VSS), U2.1 (GND), U2.9 (EP), U3.1 (GND), U4.2 (GND), U5.1 (GND), U5.2 (T-), U6.4 (V-), U6.5 (RF), U7.2 (V-), U8.3, Y1.2, Y1.4
unnamed: C21.1, R31.2, R32.1
unnamed: D2.2 (A), R15.2
unnamed: D3.2 (A), R16.2
unnamed: BZ1.2, D4.2 (A), Q1.3 (D)
unnamed: D5.2 (A), R19.2
unnamed: D6.2 (A), R20.2
unnamed: D7.2 (A), R21.2
unnamed: D8.2 (A), R22.2
unnamed: D9.1 (K), Q2.1 (G), R35.1, TP18.1, U8.4
unnamed: D10.2 (A), J9.1, Q2.2 (D)
unnamed: F2.1, J4.1
unnamed: J3.5, R11.2
unnamed: J3.6, R10.2
unnamed: J3.7, R9.2
unnamed: J3.8, R8.2
unnamed: J3.9, R7.2
unnamed: J5.A5 (CC1), R24.2
unnamed: J5.B5 (CC2), R25.2
unnamed: J6.2, R28.2
unnamed: J7.1, TP13.1, U5.3 (T+)
unnamed: NT1.1, R15.1
unnamed: NT2.1, R34.1
unnamed: Q1.1 (G), R17.1, R18.2
unnamed: R29.2, R31.1, TP14.1, U6.6
unnamed: R33.2, TP17.1, U8.1
unnamed: R34.2, U8.6
unnamed: F2.2, SW2.1 (A)
unnamed: R2.2, U1.44 (BOOT0)
unnamed: C11.1, U2.7 (BOOT)
unnamed: R29.1, R30.2, TP15.1, U6.1 (FG)
unnamed: C20.1, R32.2, U7.3 (+)
VDD: C4.1, C5.1, C6.1, FB1.1, J1.1, R1.1, R23.1, TP1.1, U1.1 (VBAT), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD)
VDDA: C7.1, C8.1, L1.2, TP2.1, U1.9 (VDDA)
